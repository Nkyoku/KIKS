# Repository Nkyoku/KIKS (continued)

## EAGLE design EagleFiles/project/KickerBoard6B/KickerBoard6B.brd

Parts:
C1: 1u; 1608
C2, C19: 1u; 1005
C3: 100u; 3225
C4: 56u; ES-6.3
C5, C16, C17: 10n; 1005
C6: 22u; 3216
C7: 1n; 1005
C8, C9, C18, C20: 100n; 1608
C10, C11, C12, C13, C14, C15: 100n; 1005
C21: 22n; 3216
CN1: To Host; 43650-0800
CN2: UX60SC-MB-5ST
CN3, CN4: 5569-02A2
D1: SMAJ24; DO-214AC
D2, D5, D6, D9: RB520S; 1608
D3: ES3G; DO-214AB
D4: SMAJ300; DO-214AC
D7, D8: AS4PG; SMPC
F1: 10; 3216
L1: 10u; L8682
LED1, LED2: LED1611R; 1611
LED3, LED4: LED1608; 1608
LOGO1: LOGO-KIKS
P1: VCC; PAD
P2: CLK; PAD
P3: DAT; PAD
P4: GND; PAD
Q1: Si4916DY; SOP8
Q2: TK12P60W; DPAK-3
Q3: BSP130; SOT223
Q4: ZXTN08400BFF; SOT23-3
Q5: BSS138; SOT23-3
Q6, Q7: IGBT-1N; TO-247AD_X1
R1, R27: 1.2M; 1608
R3: 100k; 1608
R4, R7, R22: 10k; 1608
R5: 100; 1608
R6: 2m; FC4L
R8: 2.7k; 1608
R9, R10, R30: 100k; 1005
R11, R12, R14, R24, R32, R33: 10k; 1005
R13, R34, R35: 10; 2012
R15, R16, R31: 51; 1005
R17, R18: 22; 1005
R19, R20, R21, R29: 1k; 1005
R23, R28: 1k; 1608
R25: 2.2k; RIEDON-S-3
R26: 1.5M; 1608
R36: 0.3m; WSL4026
U1: LT3080MS8; MSOP8-PAD
U2: IP4234CZ6; SOT23-6
U3: LT6108-2; MSOP8
U4: MAX15019A-NOPAD; SOP8
U5: UCC27517; SOT23-5
U6: ATXMEGA32A4U-AU; QFP44-0.8
U7: ADR5041; SC70-3
U8: INA213; SC70-6
U9: AD8601; SOT23-5
U10: UCC27524DGN-NOPAD; MSOP8
U11: MCP1700T-33; SOT23-3

Connections:
!DISCHARGE: R31.2, U6.16 (PC6/CLKRTC/MISO/RXD1)
+3V3: C3.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, D2.K, D5.K, D9.K, P1.1, R14.1, R19.2, U6.9 (VCC), U6.19 (VCC), U6.31 (VCC), U6.39 (AVCC), U8.3 (V+), U9.5 (V+)
+12V: C6.1, C9.1, C18.1, U1.1 (OUT), U1.2 (OUT), U1.3 (OUT), U1.PAD (OUT), U4.1 (VDD), U5.1 (VDD), U10.1 (ENA), U10.6 (VDD), U10.8 (ENB)
CURRENT_NEG: R36.I2, U8.5 (VIN-)
CURRENT_OUT: U6.7 (PB3/ADC11/DAC1), U8.6 (OUT)
CURRENT_POS: R36.I1, U8.4 (VIN+)
CUR_TRIP: U3.3 (OUTC), U6.3 (PA7/ADC7)
GATE_BOOST: U5.3 (IN+), U6.10 (PC0/OC0A/SDA)
GATE_BUCK_H: R9.2, U4.5 (IN_H), U6.12 (PC2/OC0C/RXD0)
GATE_BUCK_L: R10.2, U4.6 (IN_L), U6.11 (PC1/OC0B/XCK0/SCL)
GATE_KICK1: U6.15 (PC5/OC1B/MOSI/XCK1), U10.2 (INA)
GATE_KICK2: U6.14 (PC4/OC1A/!SS), U10.4 (INB)
GND: C1.2, C2.2, C3.2, C4.N, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, CN1.3, CN1.4, CN1.8, CN2.5 (GND), CN2.S1, CN2.S2, D1.A, D4.A, P4.1, Q1.4 (S2), Q2.3 (S), Q3.3 (S), R1.1, R4.1, R8.1, R9.1, R10.1, R11.1, R12.1, R20.1, R21.1, R23.1, R28.1, R30.1, R32.1, R33.1, R36.V2, U2.2 (V-), U3.4 (V-), U4.7 (GND), U5.2 (GND), U5.4 (IN-), U6.8 (GND), U6.18 (GND), U6.30 (GND), U6.38 (GND), U7.2 (A), U8.1 (REF), U8.2 (GND), U9.2 (V-), U10.3 (GND), U11.1 (GND)
LED1: LED1.A, U6.36 (PR0/XTAL2)
LED2: LED2.A, U6.37 (PR1/XTAL1)
unnamed: CN3.1, D7.1 (A), D7.2 (A), Q6.2 (C)
unnamed: Q6.1 (G), R34.2
unnamed: R33.2, R35.1, U10.5 (OUTB)
unnamed: R32.2, R34.1, U10.7 (OUTA)
unnamed: CN4.1, D8.1 (A), D8.2 (A), Q7.2 (C)
unnamed: C8.2, L1.1, Q1.5 (S1_D2), Q1.6 (S1_D2), Q1.7 (S1_D2), U4.4 (HS)
unnamed: Q6.3 (E), Q7.3 (E), R36.V1
unnamed: D3.A, L1.2, Q2.4 (D)
unnamed: C20.1, Q1.1 (D1), Q1.2 (D1), R6.V1
unnamed: C5.1, R1.2, U1.4 (SET)
unnamed: C17.1, Q5.2 (S), R24.2, R28.2
unnamed: CN1.6, D2.A
unnamed: C1.1, C4.P, CN1.1, CN1.2, D1.K, F1.1, U1.5 (VCONT), U1.7 (IN), U1.8 (IN)
unnamed: Q1.8 (G1), U4.3 (DH)
unnamed: Q1.3 (G2), R11.2, U4.8 (DL)
unnamed: C8.1, U4.2 (BST)
unnamed: R15.2, U6.32 (PE2/OC0C/RXD0)
unnamed: R16.2, U6.33 (PE3/OC0D/TXD0)
unnamed: R17.1, U6.26 (PD6/MISO/RXD1/D-)
unnamed: R18.1, U6.27 (PD7/CLKPER/SCK/TXD1/D+)
unnamed: CN2.2 (D-), U2.6 (O2)
unnamed: CN2.3 (D+), U2.1 (O1)
unnamed: P2.1, R14.2, U6.35 (!RESET!/PDI_CLK)
unnamed: C2.1, CN2.1 (VBUS), U2.5 (V+), U11.3 (VI)
unnamed: P3.1, U6.34 (PDI_DATA)
unnamed: LED1.K, R20.2
unnamed: LED2.K, R21.2
unnamed: C16.1, Q3.1 (G), Q5.3 (D), R26.1
unnamed: LED3.K, Q3.2 (D), Q3.4 (D), R25.1, R26.2, R29.1
unnamed: R22.1, R23.2, U9.4 (IN-)
unnamed: Q5.1 (G), R30.2, R31.1
unnamed: D5.A, R24.1, U9.3 (IN+)
unnamed: D6.A, LED4.K, Q4.3 (C)
unnamed: LED3.A, Q4.1 (B), R27.1
unnamed: Q4.2 (E), R29.2
unnamed: C19.1, D9.A, U11.2 (VO)
unnamed: R5.1, U3.8 (SENSEHI)
unnamed: Q7.1 (G), R35.2
unnamed: R6.I1, U3.1 (SENSELO)
unnamed: R7.1, R8.2, U3.5 (INC)
unnamed: Q2.1 (G), R13.2
unnamed: R3.2, R5.2, R6.I2, U3.2 (EN), U3.7 (V+)
unnamed: R12.2, R13.1, U5.5 (OUT)
RX: CN1.7, R16.1
TX: CN1.5, R15.1
USB_DM: R17.2, U2.4 (I2)
USB_DP: R18.2, U2.3 (I1)
VBAT: F1.2, R6.V2
VCHARGE1: C21.1, CN4.2, D3.K, D4.K, D8.K
VCHARGE2: CN3.2, D6.K, D7.K, LED4.A, R25.2, R27.2
VOLT_BAT: C7.1, R3.1, R4.2, U6.2 (PA6/ADC6)
VOLT_CAP: R22.2, U6.41 (PA1/ADC1), U9.1 (OUT)
VOLT_CUR: R7.2, U3.6 (OUTA), U6.1 (PA5/ADC5)
VOLT_REF: R19.1, U6.40 (PA0/AREF/ADC0), U7.1 (K)

Notes on the sheet:
KIKS2014
Gen.6 Kicker Board
FUJII NAOMICHI
Schemed by
Date
2013/08/31
Revision B
7.4A Limit
IHLP3232DZER100M01

Board: 2 copper layers, 100.0 x 50.0 mm, 98 parts (5 on the bottom side), 69 nets.

## EAGLE design EagleFiles/project/KickerBoard5/KickerBoard5.brd

Parts:
C1: 22u; 2012
C2, C3: 220u; E3.5-8
C4, C6: 10n; 1005
C5: 22u; 3225
C7, C10, C21: 22u; 3216
C8, C11, C13, C14, C15, C16, C19, C20: 100n; 1005
C9: 100n; 1608
C12, C18, C23: 1u; 1608
C17, C24, C25: 1u; 1005
C22: 22n; 3216
CN1: 43045-0800
CN2: UX60SC-MB-5ST
CN3: Fan; PIN1X2
CN4: Capacitor; TERMINAL2P-V-SCLEWLESS
CN5: Straight; 5569-02A2
CN6: Chip; 5569-02A2
D1, D2: SMAJ22; DO-214AC
D3, D4: PMEG4030ER; SOD123W
D5: 15ETH06FP; TO-220F-2
D6, D10: CDSU101A; 1608
D7: SMAJ300; DO-214AC
D8, D9: ES3G; DO-214AB
F1: 8; 3216
FB1: FB1608; 1608
H1, H2: SSB-003; SBB-003
HT1: HEATSINK-271; 271-AB
L1: 10u; L4040
L2: 200u; COIL-V
LED1, LED2, LED3: LED1608; 1608
LOGO1: LOGO-876_SMALL
LOGO2: LOGO-HV; LOGO-HIGHVOLTAGE
P1: VCC; PAD
P2: CLK; PAD
P3: DAT; PAD
P4: GND; PAD
Q1, Q3: MOS-N-SOT23; SOT23-3
Q2: SI4483ADY; SOP8
Q4: SIHP12N60E; TO-220F
Q5, Q6: FGA180N33ATD; TO-3P
R1, R9, R21, R22, R23, R24, R37: 1k; 1005
R2, R7: 100k; 1608
R3, R8, R31, R32, R34: 10k; 1608
R4: 33k; 1005
R5, R17, R18, R26, R27, R29, R38, R39, R42, R43: 10k; 1005
R6, R19, R20, R25: 51; 1005
R10: R1005; 1005
R11: 100k; 1005
R12: 0.1; 2012
R13: 24k; 1608
R14: 7.5k; 1608
R15, R16: 22; 1005
R28, R40, R41: 47; 3216
R30: 2m; FC4L
R33: 1.5M; 1608
R35, R36: 500k; 1608
U1: LM25011; MSOP10-PAD
U2: IP4234CZ6; SOT23-6
U3: ATXMEGA32A4U-MH; QFN44-0.5
U4: MCP9701/LT; SC70-6
U5: ADR5041; SC70-3
U6: UCC27517; SOT23-5
U7, U8: SINGLE-OPAMP-ISO-SOT23; SOT23-5
U9: UCC27524DGN; MSOP8-PAD
U10: MCP1700T-33; SOT23-3

Connections:
+3V3: C1.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C19.1, C20.1, D6.K, D10.K, FB1.1, P1.1, R17.1, U3.9 (VCC), U3.19 (VCC), U3.31 (VCC), U3.39 (AVCC), U4.4 (VDD), U7.5 (V+), U8.5 (V+)
+9V: C10.1, C18.1, C21.1, C23.1, CN3.1, D4.K, L1.2, R13.2, U6.1 (VDD), U9.1 (ENA), U9.6 (VDD), U9.8 (ENB)
CHARGER_RX: CN1.5, R20.2
CHARGER_TX: CN1.6, R19.2
CUR_OFFSET: R35.1, U3.6 (PB2/ADC10/DAC0)
CUR_OUT: R36.1, U3.7 (PB3/ADC11/DAC1), U7.1 (OUT)
GATE_CHIP: R38.2, U3.12 (PC2/OC0C/RXD0), U9.2 (INA)
GATE_CHOPPER: R27.2, U3.10 (PC0/OC0A/SDA), U6.3 (IN+)
GATE_STRAIGHT: R39.2, U3.11 (PC1/OC0B/XCK0/SCL), U9.4 (INB)
GND: C1.2, C2.N, C3.N, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, CN1.1, CN1.3, CN1.7, CN2.5 (GND), CN2.S1, CN2.S2, CN4.2, CN4.2B (2), D1.A, D2.A, D7.A, P4.1, Q1.2 (S), Q3.2 (S), Q5.3 (E), Q6.3 (E), R3.1, R5.1, R8.1, R12.1, R14.1, R18.1, R22.1, R23.1, R24.1, R26.2, R27.1, R29.1, R30.V1, R34.1, R38.1, R39.1, R42.1, R43.1, U1.5 (SGND), U1.9 (CSG), U1.PAD (SGND), U2.2 (V-), U3.8 (GND), U3.18 (GND), U3.30 (GND), U3.38 (GND), U4.2 (GND), U5.2 (A), U6.2 (GND), U6.4 (IN-), U7.2 (V-), U8.2 (V-), U9.3 (GND), U9.PAD (GND), U10.1 (GND)
LED1: LED1.A, U3.20 (PD0/OC0A)
LED2: LED2.A, U3.21 (PD1/OC0B/XCK0)
unnamed: R11.1, U1.2 (RT)
unnamed: R1.2, R2.1, R3.2
unnamed: R7.1, R8.2, R9.1
unnamed: R40.1, U9.7 (OUTA)
unnamed: P2.1, R17.2, U3.35 (!RESET!/PDI_CLK)
unnamed: Q4.3 (S), R30.V2
unnamed: C24.1, CN2.1 (VBUS), U2.5 (V+), U10.3 (VI)
unnamed: P3.1, R18.2, U3.34 (PDI_DATA)
unnamed: D5.3 (A), L2.2, Q4.2 (D)
unnamed: D6.A, R37.2, U8.3 (IN+)
unnamed: CN2.2 (D-), U2.6 (O2)
unnamed: C8.1, R10.2, U1.4 (SS)
unnamed: C9.1, U1.6 (BST)
unnamed: R30.I2, R31.2
unnamed: R31.1, R35.2, U7.3 (IN+)
unnamed: R32.1, R36.2, U7.4 (IN-)
unnamed: R13.1, R14.2, U1.10 (FB)
unnamed: Q6.1 (G), R40.2, R43.2
unnamed: C9.2, D3.K, L1.1, U1.7 (SW)
unnamed: CN2.3 (D+), U2.1 (O1)
unnamed: CN5.1, D8.A, Q5.2 (C)
unnamed: Q1.3 (D), Q2.4 (G), R4.1
unnamed: R28.1, U6.5 (OUT)
unnamed: CN6.1, D9.A, Q6.2 (C)
unnamed: Q4.1 (G), R28.2, R29.2
unnamed: LED2.K, R23.2
unnamed: R41.1, U9.5 (OUTB)
unnamed: Q5.1 (G), R41.2, R42.2
unnamed: R30.I1, R32.2
unnamed: R19.1, U3.22 (PD2/OC0C/RXD0)
unnamed: D3.A, R12.2, U1.8 (CS)
unnamed: R20.1, U3.23 (PD3/OC0D/TXD0)
unnamed: CN1.2, FB1.2
unnamed: LED1.K, R22.2
unnamed: LED3.K, R24.2
unnamed: C25.1, D10.A, U10.2 (VO)
unnamed: CN3.2, D4.A, Q3.3 (D)
unnamed: R16.1, U2.3 (I1)
unnamed: Q3.1 (G), R25.2
unnamed: R15.1, U2.4 (I2)
unnamed: Q1.1 (G), R6.1
PWR_CHARGER: LED3.A, R5.2, R6.2, U3.29 (PE1/OC0B/XCK0/SCL)
PWR_FAN: R25.1, R26.1, U3.13 (PC3/OC0D/TXD0)
PWR_GATE: R10.1, U3.33 (PE3/OC0D/TXD0)
REF_V+: R21.2, U3.2 (PA6/ADC6)
TEMP: U3.43 (PA3/ADC3), U4.3 (VOUT)
USB_D+: R16.2, U3.27 (PD7/CLKPER/SCK/TXD1/D+)
USB_D-: R15.2, U3.26 (PD6/MISO/RXD1/D-)
VBAT: C2.P, C3.P, C7.1, CN1.4, CN1.8, Q2.1 (S), Q2.2 (S), Q2.3 (S), R2.2, R4.2, R11.2, U1.1 (VIN)
VCAP: C22.1, CN4.1, CN4.1B (1), CN5.2, CN6.2, D5.1 (K), D7.K, D8.K, D9.K, R33.2
VCC/1: D1.K, F1.1, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D)
VCC/2: C5.1, D2.K, F1.2, L2.1, R7.2
VOLT_BAT: C4.1, R1.1, U3.42 (PA2/ADC2)
VOLT_CAP: U3.44 (PA4/ADC4), U8.1 (OUT), U8.4 (IN-)
VOLT_LINE: C6.1, R9.2, U3.41 (PA1/ADC1)
VOLT_LINE1: R33.1, R34.2, R37.1
VOLT_REF: C17.1, R21.1, U3.4 (PB0/AREF/ADC8), U5.1 (K)

Notes on the sheet:
KIKS2013
Gen.5 Kicker Board
FUJII NAOMICHI
Schemed by
Date
2012/12/03
ベースボードから
電流センスが必要だったら実装する 応答性が求められるのでディスクリート
10.5Vくらい
Revision A

Board: 2 copper layers, 90.0 x 38.0 mm, 116 parts (83 on the bottom side), 69 nets.

## Code that names these connections

File Gen5/FPGA/Constraint/Main.ucf:

// ピン制約

NET "CLK_IN"			LOC = P50	| IOSTANDARD = LVCMOS33;
NET "PWR_5V"			LOC = P40	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;

NET "nINIT"				LOC = P39	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "AUX0"				LOC = P69	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| PULLUP;
NET "AUX1"				LOC = P64	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| PULLUP;
NET "AUX2"				LOC = P48	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| PULLUP;

NET "SPI_nCS"			LOC = P67	| IOSTANDARD = LVCMOS33;
NET "SPI_SCLK"			LOC = P56	| IOSTANDARD = LVCMOS33;
NET "SPI_SCLK2"			LOC = P70	| IOSTANDARD = LVCMOS33;
NET "SPI_MOSI"			LOC = P65	| IOSTANDARD = LVCMOS33;
NET "SPI_MISO"			LOC = P66	| IOSTANDARD = LVCMOS33	| DRIVE = 4	| SLEW = SLOW;

NET "MOT1_PWM[0]"		LOC = P102	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_PWM[1]"		LOC = P100	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_PWM[2]"		LOC = P97	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_nRESET[0]"	LOC = P101	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_nRESET[1]"	LOC = P99	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_nRESET[2]"	LOC = P98	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT1_nFAULT"		LOC = P104	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "MOT1_nOTW"			LOC = P105	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT2_PWM[0]"		LOC = P81	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_PWM[1]"		LOC = P79	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_PWM[2]"		LOC = P74	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_nRESET[0]"	LOC = P80	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_nRESET[1]"	LOC = P78	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_nRESET[2]"	LOC = P75	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT2_nFAULT"		LOC = P82	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "MOT2_nOTW"			LOC = P83	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT3_PWM[0]"		LOC = P32	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_PWM[1]"		LOC = P29	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_PWM[2]"		LOC = P24	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_nRESET[0]"	LOC = P30	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_nRESET[1]"	LOC = P27	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_nRESET[2]"	LOC = P26	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT3_nFAULT"		LOC = P33	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "MOT3_nOTW"			LOC = P34	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT4_PWM[0]"		LOC = P9	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_PWM[1]"		LOC = P7	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_PWM[2]"		LOC = P2	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_nRESET[0]"	LOC = P8	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_nRESET[1]"	LOC = P6	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_nRESET[2]"	LOC = P5	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT4_nFAULT"		LOC = P10	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "MOT4_nOTW"			LOC = P11	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT5_PWM[0]"		LOC = P140	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_PWM[1]"		LOC = P138	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_PWM[2]"		LOC = P133	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_nRESET[0]"	LOC = P139	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_nRESET[1]"	LOC = P137	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_nRESET[2]"	LOC = P134	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW	| IOB = FORCE;
NET "MOT5_nFAULT"		LOC = P141	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "MOT5_nOTW"			LOC = P142	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT12_EN_SENSORS"	LOC = P84	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "MOT12_nLATCH"		LOC = P95	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "MOT12_CLK"			LOC = P94	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "MOT12_nDO"			LOC = P93	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT345_EN_SENSORS"	LOC = P12	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "MOT345_nLATCH"		LOC = P23	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "MOT345_CLK"		LOC = P22	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "MOT345_nDO"		LOC = P21	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "ADC1_nCS"			LOC = P92	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC1_SCLK"			LOC = P88	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC1_MOSI"			LOC = P87	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC1_MISO"			LOC = P85	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "ADC2_nCS"			LOC = P17	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC2_SCLK"			LOC = P16	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC2_MOSI"			LOC = P15	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "ADC2_MISO"			LOC = P14	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "MOT5_CUR_SDA"		LOC = P143	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "MOT5_CUR_SCL"		LOC = P144	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;

//NET "MOT1_TEMP"			LOC = P111	| IOSTANDARD = LVCMOS33	| PULLUP;
//NET "MOT3_TEMP"			LOC = P35	| IOSTANDARD = LVCMOS33	| PULLUP;
//NET "MOT4_TEMP"			LOC = P1	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "EXT1_nCS"			LOC = P119	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "EXT1_SCLK"			LOC = P121	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "EXT1_MOSI"			LOC = P124	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "EXT1_MISO"			LOC = P127	| IOSTANDARD = LVCMOS33	| PULLUP;
NET "EXT1_CE"			LOC = P117	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "EXT1_IRQ"			LOC = P132	| IOSTANDARD = LVCMOS33	| PULLDOWN;

NET "BALL_EN"			LOC = P116	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "BALL_SCL"			LOC = P114	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "BALL_DETECT"		LOC = P112	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;

NET "XBEE_nRESET"		LOC = P123	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = QUIETIO;
NET "XBEE_TX"			LOC = P120	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "XBEE_RX"			LOC = P118	| IOSTANDARD = LVCMOS33	| PULLUP	| IOB = FORCE;
NET "XBEE_nCTS"			LOC = P115	| IOSTANDARD = LVCMOS33	| PULLUP;

NET "LED_CLK"			LOC = P131	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;
NET "LED_DO"			LOC = P126	| IOSTANDARD = LVCMOS33	| DRIVE = 2	| SLEW = SLOW;

// タイミング制約

//TEMPERATURE = 50 C;

NET "CLKGEN/clksys2"	TNM_NET = "TNM_CLKGEN_CLKSYS2";
TIMESPEC "TS_CLKGEN_CLKSYS2" = PERIOD "TNM_CLKGEN_CLKSYS2" 6.666 ns HIGH 50 %;	// 150MHz

NET "CLKGEN/clksys1"	TNM_NET = "TNM_CLKGEN_CLKSYS1";
TIMESPEC "TS_CLKGEN_CLKSYS1" = PERIOD "TNM_CLKGEN_CLKSYS1" 20.000 ns HIGH 50 %;	// 50MHz

NET "CLKGEN/clkpwm"	TNM_NET = "TNM_CLKGEN_CLKPWM";
TIMESPEC "TS_CLKGEN_CLKPWM" = PERIOD "TNM_CLKGEN_CLKPWM" 6.944 ns HIGH 50 %;	// 144MHz

NET "SPI_SCLK"			TNM_NET = "TNM_SPISCLK";
TIMESPEC "TS_SPISCLK" = PERIOD "TNM_SPISCLK" 16.666 ns HIGH 50 %;				// 最大60MHz

// 配置制約

File Gen5/UC3B/Source/main.cpp:

/**	@file
	@brief メイン
*/

// マクロのチェック
#ifdef _DFU_
#ifdef _APP_
#error Both _DFU_ and _APP_ are defined.
#endif
#endif
#ifndef _DFU_
#ifndef _APP_
#error Both _DFU_ and _APP_ are not defined.
#endif
#endif

// virtualメソッドを使うときにコードが肥大化することへの対処
extern "C" void __cxa_pure_virtual(){while(true);}

#define _MAIN_CPP_

#include "driver/boot.h"
#include "driver/int.h"
#include "driver/clock.h"
#include "driver/gpio.h"
#include "driver/adc.h"
#include "driver/time.h"
#include "driver/debugIF.h"
#include "driver/usb.h"
#include "driver/spi.h"
#include "driver/spartan6.h"
#include "driver/mx25l6445e.h"
#include "driver/kicker.h"

#include "ff.h"
#include "HAL/TTY.h"
#include "HAL/BTLUSB.h"

#include "FreeRTOS.h"
#include "task.h"

#include "safety_task.h"
//#include "shell_task.h"
//#include "usb_task.h"
//#ifdef _APP_
//#include "main_task.h"
//#endif

#include "global.h"

// メイン
int main(void){
#ifdef _DFU_
	// 起動フラグを見て分岐
	Boot::JumpToAPPIfNecessary();
#else
	// 起動フラグが正常かチェック
	Boot::CheckFlagAtAPP();
#endif
	
	// HMATRIXの優先度設定
	//AVR32_HMATRIX.prs[3].pras = 3 << AVR32_HMATRIX_PRAS3_M3PR;
	
	// システム初期化
	GPIO::Init();
	Clock::Init();
	Int::Init();
	Time::Init();
	ADC::Init();
	nsDebugIF::Init();
	USB::Init();
	SPI::Init();
	FPGA::Init();
	SPIFlash::Init();
#ifdef _APP_
	Kicker::Init();
#endif
	
	// RTOS初期化
	Tick_Init();
	
	// ジャンパ読み取り
	int id = 0;
	if (GetIn(PIN_SETTING_ID2) == IN_LOW) id |= 0x4;
	if (GetIn(PIN_SETTING_ID1) == IN_LOW) id |= 0x2;
	if (GetIn(PIN_SETTING_ID0) == IN_LOW) id |= 0x1;
	g_MachineID = id;
	if (GetIn(PIN_SETTING_CHARGER) == IN_LOW) g_HiResEncoder = true;	// 現在はエンコーダの識別のために使用
	
	// タスク作成
	xTaskCreate(SafetyTask::Task, "Safety", 1024, NULL, PRIORITY_LOW, NULL);
	
	// RTOSスタート
	vTaskStartScheduler();
	
	return 0;
}

File Gen5/UC3B/Source/shell_task.cpp (part):

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			if (args == 2){
				if (arg_int[1] == 0){
					xputs("12V OFF\n");
					SetOut(PIN_PWR_12V, OUT_LOW);
				}else{
					xputs("12V ON\n");
					SetOut(PIN_PWR_12V, OUT_HIGH);
				}
			}
			break;
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			if (args == 2){
				if (arg_int[1] == 0){
					xputs("Driver OFF\n");
					SetOut(PIN_PWR_MOTOR1, OUT_LOW);
					SetOut(PIN_PWR_MOTOR2, OUT_LOW);
				}else{
					xputs("Driver ON\n");
					SetOut(PIN_PWR_MOTOR1, OUT_HIGH);
					SetOut(PIN_PWR_MOTOR2, OUT_HIGH);
				}
			}
			break;
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
## Commit log

2014-03-17 最初のコミット
2014-03-17 no message
2014-03-20 OMSPのボールセンサーとUARTの修正
2014-03-26 Terminalでボールセンサの値が取れないことの修正
    AVRのプログラム(UC3B)のmain_task内でTerminalにログを送る部分で
    何故かボールセンサの値を送ってなかったので送るように変更した
2014-03-26 モーター制御でPI制御を行うための修正
    Motorモジュールの初期化が行われていなかったので、mainを修正
    現在速度の向きが時計回り(Dutyで設定する方向)とは逆だったので、修正
    逆起電力定数を指令速度値に乗じていたので、現在速度値に乗じるよう修正
2014-03-28 main.bitの追加
    FPGAのビルド（論理回路化と配線）には時間がかかるので、完成したものをあげておく
2014-03-28 UC3Bのロガーのプログラムの改良
    GPIAとGPIBは連続したレジスタなのでいちいち参照先を変えないで連続してみるように変更
2014-03-28 PI制御を行うことに伴う修正
    エンコーダの正負を切り替える場所がおかしかったので修正
    PI制御パラメータK_PとK_Iの修正
    ロガーでTerminalに送るデータの変更
    積分値の制限領域の変更
    指令値の変化が大きすぎるとモータードライバーICが止まってしまうので、duty値に制限領域をもたせることで対応
    コメントで入れていた前回のモーター制御のプログラムを削除
2014-03-28 文章の添削
    Nkyokuさんの編集版
2014-03-28 一度、リリースするために最初のバージョン(フィードフォワード版)に直す
2014-03-28 PI制御対応版
2014-03-28 PI制御版
    PI制御一通り完全版
2014-03-28 回転暴走防止版
    回転防止制御を行うための諸々の仕様の変更
2014-04-01 Revert "PI制御対応版"
    This reverts commit 0f0d99f4d1c0754f0a4cad712d19b2d89ee07386.
2014-04-14 回転暴走抑制版のとりあえず、最終版
    まだ実用には達していないが、別の開発に移ることにしたので(カルマンフィルタのコーディング)暫定のバージョンを挙げておく
    以下前回のcommitからの変更点
    ・ロガーのIDの変更
    ・LEDの色の変更
    ・ゲイン調整その他もろもろ
2014-04-16 コメントの書き方の修正
2014-04-24 新受信フォーマット仕様への変更
    AIからの要望により、ドリブルパワーと移動方向の精度をあげてみることにした
    以下はその変更仕様
    ・ドリブルパワーを2ビットから3ビットの8段階に
    ・移動方向に9ビット目を付加
    この二つは未使用であった5バイト目(バイト4)の0:2ビットと6ビットで対応
    これによる変更点
2014-05-06 キャパシタ昇圧電圧を220Vにした
    Chargeの昇圧終止電圧と、再充電開始電圧の変更
    TerminalWriteHEXにpauseをいれた
