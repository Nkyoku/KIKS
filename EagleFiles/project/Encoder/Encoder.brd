# Repository Nkyoku/KIKS (continued)

## EAGLE design EagleFiles/project/BaseBoard5A/BaseBoard5.brd

Parts:
C1: 100n; 1005
C2: 100n; 1608
C3, C4: 100u; ES-6.3
C5, C6, C12, C20, C166, C167: 10n; 1005
C7: 330u; ES2-8
C8, C19: 1u; 1005
C9, C16: 22u; 3225
C10, C11, C13: 1u; 1608
C14: 1n; 1005
C15, C18: 100u; 3225
C17, C21: 22u; 3216
CN1: Battery; T-CON
CN2: Kicker; 43045-0800
D1, D2: SMAJ22A; DO-214AC
D3, D5, D6, D7, D8: PMEG4030ER; SOD123W
D4: SMAJ24A; DO-214AC
F1: 15; 3216
F2, F3: 10; 3216
L1, L4, L5: 4.7u; L2520
L2: 3.3u; L2520
L3: 10u; L4040
LOGO1: LOGO-876_SMALL
Q1, Q2: MOS-N-SOT23; SOT23-3
Q3, Q4: Si4483ADY; SOP8
R1: 2m; FC4L
R2, R3, R8, R11, R12, R22, R27, R28: 10k; 1005
R4, R6, R9: 100k; 1608
R5, R7: 10k; 1608
R10, R16, R18, R20: 24k; 1608
R13, R25, R26, R122, R123: 1k; 1005
R14, R19: 3.9k; 1608
R15, R21: 7.5k; 1608
R17: 1.65k; 1608
R23, R24: 33k; 1005
R29, R30: 51; 1005
SW1: Power; SLE6_10A4
U1: INA219DCN; SOT23-8
U2: LT3504; QFN28-0.5-PAD
U3: SPX3819-50; SOT23-5

Connections:
+1V2: C15.1, L2.2, R14.2; also elsewhere on the board
+3V3: C1.1, C18.1, CN2.2, L5.2, R2.2, R3.2, R20.2, U1.4 (VS); also elsewhere on the board
+5V: C21.1, U3.5 (OUT); also elsewhere on the board
+12V: C14.2, C16.1, L3.2, R6.2, R16.2; also elsewhere on the board
CHARGER_RX: CN2.5; also elsewhere on the board
CHARGER_TX: CN2.6; also elsewhere on the board
GND: C1.2, C2.2, C3.N, C4.N, C5.2, C6.2, C7.N, C8.2, C9.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, CN1.N, CN2.1, CN2.3, CN2.7, D1.A, D2.A, D4.A, R5.1, R7.1, R10.1, R11.1, R12.1, R15.1, R17.1, R19.1, R21.1, R22.1, R25.1, R26.1, R27.1, R28.1, U1.3 (GND), U1.7 (A0), U1.8 (A1), U2.10 (GND), U2.18 (GND), U2.27 (GND), U2.PAD, U3.2 (GND); also elsewhere on the board
unnamed: C8.1, R8.2, R11.2, U2.14 (RUN/SS2)
unnamed: C10.1, U2.25 (SKY)
unnamed: L1.2, U2.24 (SW5)
unnamed: C12.1, U2.12 (RUN/SS4), U2.13 (RUN/SS1), U2.15 (RUN/SS3)
unnamed: D8.A, U2.8 (DA4)
unnamed: D7.A, U2.3 (DA3)
unnamed: D8.K, L5.1, U2.7 (SW4)
unnamed: R12.2, U2.17 (RT/SYNC)
unnamed: D6.A, U2.1 (DA2)
unnamed: D5.K, L2.1, U2.5 (SW1)
unnamed: R18.1, R19.2, U2.21 (FB3)
unnamed: D6.K, L3.1, R13.2, U2.2 (SW2)
unnamed: D7.K, L4.1, U2.4 (SW3)
unnamed: R9.1, R10.2, U2.16 (EN/UVLO)
unnamed: R20.1, R21.2, U2.19 (FB4)
unnamed: R14.1, R15.2, U2.20 (FB1)
unnamed: R16.1, R17.2, U2.22 (FB2)
unnamed: C17.1, C19.1, L4.2, R18.2, U3.1 (IN)
unnamed: C166.1, F2.1, Q3.5 (D), Q3.6 (D), Q3.7 (D), Q3.8 (D)
unnamed: R1.I1, U1.1 (VIN+)
unnamed: C166.2, Q1.3 (D), Q3.4 (G), R23.1
unnamed: C14.1, R13.1
unnamed: C7.P, C9.1, C10.2, C11.1, C13.1, D3.K, D4.K, L1.1, R9.2, U2.9 (VIN), U2.11 (VIN), U2.26 (VIN), U2.28 (VIN)
unnamed: Q1.2 (S), R25.2
unnamed: C167.1, F3.1, Q4.5 (D), Q4.6 (D), Q4.7 (D), Q4.8 (D)
unnamed: D5.A, U2.6 (DA1)
unnamed: C167.2, Q2.3 (D), Q4.4 (G), R24.1
unnamed: Q2.1 (G), R30.1
unnamed: Q1.1 (G), R29.1
unnamed: C20.1, U3.4 (NR)
unnamed: CN1.P, F1.1
unnamed: Q2.2 (S), R26.2
unnamed: R1.I2, U1.2 (VIN-)
unnamed: D1.K, F1.2, R1.V1
unnamed: R1.V2, SW1.P (A)
unnamed: R4.1, R5.2, R122.1
unnamed: R6.1, R7.2, R123.1
POWER_SCL: R2.1, U1.5 (SCL); also elsewhere on the board
POWER_SDA: R3.1, U1.6 (SDA); also elsewhere on the board
PWR_5V: R22.2, U3.3 (EN); also elsewhere on the board
PWR_12V: R8.1; also elsewhere on the board
PWR_MOTOR1: R27.2, R29.2; also elsewhere on the board
PWR_MOTOR2: R28.2, R30.2; also elsewhere on the board
VBAT: C2.1, C3.P, C4.P, CN2.4, CN2.8, D2.K, D3.A, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), R4.2, R23.2, R24.2, SW1.1 (B)
VCC/1: F2.2; also elsewhere on the board
VCC/2: F3.2; also elsewhere on the board
VOLT_12V: C6.1, R123.2; also elsewhere on the board
VOLT_BAT: C5.1, R122.2; also elsewhere on the board

Notes on the sheet:
コンデンサの充電器へ
モーター1,2へ
FPGA用
各種ロジック
ホールセンサー・アナログ系
モータードライバー
モーター3,4,5へ
KIKS2013
Gen.5's Base Board
FUJII NAOMICHI
Designed by
Date
2012/09/23

Parts:
C22, C26, C27, C28, C29, C30, C32, C33, C34, C35, C37: 100n; 1005
C23: 10n; 1005
C25: 1n; 1005
C31: 22u; 2012
C36: 10u; 1608
CN3: UX60SC-MB-5ST
CN4: CN-JTAG_ALTERA-BOX; PIN2X5-BOX
CN5: Debug; 70553-0003
J1: Setting; PIN2X5-2.0
LED1, LED2, LED3: LED1608; 1608
R31, R32, R33, R38, R39: 51; 1005
R34, R35: 22; 1005
R36, R37: 10k; 1005
R40, R41, R42: 1k; 1005
RA1: 51; 1005-A4
SW2, SW3: EVQ-P2-RECTANGLE; EVQ-P2_P9
U4: IP4234CZ6; SOT23-6
U5: AT32UC3B0512-AU; QFP64-0.5
U6: TFBS4650
U7: MX25L6445EM; SOP8W
X1: 24MHz; OSC2520

Connections:
!FLASH_CS: U5.37 (PA17/TC-CLK2/SPI0-SCK/SPI0-NPCS1/USART1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), U7.1 (!CS)
!FPGA_CS: U5.27 (PB05/USART1-RTS/SPI0-NPCS2/PWM5); also elsewhere on the board
!FPGA_INIT: U5.38 (PB06/SSC-RXCLK/USART1-DCD/ABDAC-DATA0); also elsewhere on the board
!FPGA_PROG: U5.36 (PA16/PWM4/TC-CLK1/SPI0-NPCS0); also elsewhere on the board
!LED3: LED3.K, U5.55 (PB09/SSC-TXCLK/USART1-RI/ABDAC-DATAN1)
!MCU_RESET: R36.1, SW2.B2, U5.63 (!RESET)
!SETTING_BOOTLOADER: J1.2, U5.10 (PA04/AD1/GCLK1/USB_VBOF/ABDAC-DATAN0)
!SETTING_CHARGER: J1.4, U5.7 (PB01/TC-B0/USART2-RTS)
!SETTING_ID0: J1.6, U5.11 (PA05/AD2/INT0/USART1-DCD/ABDAC-DATA1)
!SETTING_ID1: J1.8, U5.12 (PA06/AD3/INT1/USART1-DSR/ABDAC-DATAN1)
!SETTING_ID2: J1.10, U5.13 (PA07/AD4/PWM0/USART1-DTR/SSC-RXFRM)
!SW1: SW3.B2, U5.16 (PA31/AD7/PWM6)
+1V8: C25.1, C27.1, C29.1, C31.1, C32.1, C34.1, U5.8 (VDDCORE), U5.20 (VDDOUT), U5.22 (VDDCORE), U5.53 (VDDPLL), U5.56 (VDDCORE)
+3V3: C23.1, C26.1, C28.1, C30.1, C33.1, C35.1, C37.1, CN4.4 (VCC), CN5.3, R36.2, R37.2, R42.2, RA1.B1 (1), RA1.D1 (1), U5.18 (ADVREF), U5.19 (VDDANA), U5.21 (VDDIN), U5.32 (VDDIO), U5.48 (VDDIO), U5.64 (VDDIO), U7.3 (!WP!/SIO2), U7.8 (VCC), X1.4 (VDD); also elsewhere on the board
CHARGER_RX: R39.2; also elsewhere on the board
CHARGER_TX: R38.2; also elsewhere on the board
DEBUG_RX: CN5.2, RA1.C2 (2)
DEBUG_TX: CN5.1, RA1.A2 (2)
FPGA_AUX0: U5.30 (PA11/XIN32/PWM0/TC-A2/USART0-RTS/SSC-RX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); also elsewhere on the board
FPGA_AUX1: U5.26 (PB04/USART1-CTS/SPI0-NPCS3/TC-CLK2); also elsewhere on the board
FPGA_AUX2: U5.40 (PA19/XOUT0/PWM6/USART0-TXD/SPI0-MOSI/SS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); also elsewhere on the board
FPGA_CLK: R32.2; also elsewhere on the board
FPGA_CONF: U5.33 (PA13/PWM2/NMI/USART0-CLK/SSC-RXCLK); also elsewhere on the board
FPGA_DONE: U5.31 (PA12/XOUT32/PWM1/TC-B2/USART0-CTS/USART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); also elsewhere on the board
GND: C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, CN3.5 (GND), CN3.S1, CN3.S2, CN4.2 (GND), CN4.10 (GND), CN5.4, J1.1, J1.3, J1.5, J1.7, J1.9, LED1.K, LED2.K, SW2.A1, SW2.A2, SW3.A1, SW3.A2, U4.2 (V-), U5.1 (GND), U5.17 (GNDANA), U5.23 (GND), U5.49 (GND), U6.7 (GND), U7.4 (GND), X1.2 (GND); also elsewhere on the board
IRDA_RX: U5.59 (PA24/INT4/USART1-RXD/SPI0-NPCS0/PWM1), U6.4 (RXD)
IRDA_SD: U5.54 (PB08/SSC-RXFRM/USART1-DTR/ABDAC-DATA1), U6.5 (SD)
IRDA_TX: U5.47 (PA23/INT3/USART1-TXD/SPI0-NPCS1/PWM0), U6.3 (TXD)
LED1: R40.2, U5.24 (PB02/TC-A1/USART1-TXD)
LED2: R41.2, U5.25 (PB03/TC-B1/USART1-RXD)
MCU_CLK: R31.2, U5.41 (PA28/XIN1/USART0-CLK/PWM4/SPI0-MISO/ABD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)
MOT2_TEMP: U5.15 (PA30/AD6/GCLK2); also elsewhere on the board
unnamed: R39.1, U5.62 (PA27/TC-B0/USB_VBOF/USART2-RXD/ABDAC-DA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)
unnamed: R34.2, U5.50 (DP)
unnamed: CN3.2 (D-), U4.6 (O2)
unnamed: LED1.A, R40.1
unnamed: LED2.A, R41.1
unnamed: R35.2, U5.51 (DM)
unnamed: R35.1, U4.4 (I2)
unnamed: R34.1, U4.3 (I1)
unnamed: C36.1, RA1.B2 (2), U6.6 (VCC)
unnamed: LED3.A, R42.1
unnamed: CN4.1 (TCK), R37.1, U5.2 (TCK)
unnamed: RA1.C1 (1), U5.57 (PB10/SSC-TXDAT/TC-A2/USART0-RXD)
unnamed: R33.1, U5.52 (VBUS)
unnamed: RA1.D2 (2), U6.1 (IREDA)
unnamed: CN4.9 (TDI), U5.3 (PA00/TDI)
unnamed: CN4.3 (TDO), U5.4 (PA01/TDO)
unnamed: CN4.5 (TMS), U5.5 (PA02/TMS)
unnamed: R31.1, R32.1, X1.3 (OUT)
unnamed: CN3.3 (D+), U4.1 (O1)
unnamed: RA1.A1 (1), U5.58 (PB11/SSC-TXFRM/TC-B2/USART0-TXD)
unnamed: R38.1, U5.61 (PA26/TC-A0/USB_ID/USART2-TXD/ABDAC-DATA1)
unnamed: C22.1, CN3.1 (VBUS), R33.2, U4.5 (V+)
OSC_EN: U5.42 (PA29/XOUT1/TC-CLK0/TC-CLK1/SPI0-MOSI), X1.1 (EN)
POWER_SCL: U5.28 (PA09/SCL/SPI0-NPCS2/USART1-CTS), U5.46 (PA22/TC-B1/PWM6/TRIGGER/ABDAC-DATA0); also elsewhere on the board
POWER_SDA: U5.29 (PA10/SDA/SPI0-NPCS3/USART1-RTS), U5.45 (PA21/TC-A1/PWM2/USART2-TXD/SSC-TXFRM); also elsewhere on the board
PWR_12V: U5.43 (PB07/SSC-RXDAT/USART1-DSR/ABDAC-DATAN0); also elsewhere on the board
PWR_MOTOR1: U5.6 (PB00/TC-A0/USART2-CTS); also elsewhere on the board
PWR_MOTOR2: U5.44 (PA20/TC-CLK0/USART1-CLK/USART2-RXD/SSC-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); also elsewhere on the board
SPI_MISO: U5.39 (PA18/XIN0/PWM5/USART0-RXD/SPI0-MISO/SSC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), U7.2 (SO/SIO1); also elsewhere on the board
SPI_MOSI: U5.34 (PA14/PWM3/INT2/SPI0-MOSI/GCLK2), U7.5 (SI/SIO0); also elsewhere on the board
SPI_SCLK: U5.35 (PA15/PWM4/USART2-CLK/SPI0-SCK), U7.6 (SCLK); also elsewhere on the board
VOLT_12V: U5.14 (PA08/AD5/PWM1/USART1-RI/SSC-RXCLK); also elsewhere on the board
VOLT_BAT: U5.9 (PA03/AD0/GCLK0/USB_ID/ABDAC-DATA0); also elsewhere on the board

Notes on the sheet:
ジャンパーによる設定
なんとなくパターンだけあるIrDAトランシーバ
ほぼ使わない有線デバッグインターフェース

Parts:
BZ1: PKLCS1212E4001; PKLCS1212
C38, C41, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52, C53, C54, C57, C59, C61: 100n; 1005
C39, C40, C65: 1n; 1005
C42, C63: 100u; 3225
C55, C56, C58, C60, C62: 100n; NFM18
C64: 1u; 1005
C66: 1u; 1608
C67: 22u; 2012
CN6: External SPI 1; PIN1X8
CN7: XBee; XBEE-TH
CN8: Ball Sensor; 53375-04
CN18: External SPI 2; PIN2X4
FB1: FB1608; 1608
LED4, LED5, LED6, LED7, LED8, LED9, LED10: LED1608; 1608
P1: TCK; PAD
P2: TDI; PAD
P3: TDO; PAD
P4: TMS; PAD
R44, R45, R53, R60, R61: 10k; 1005
R46, R47, R48, R49, R50, R51, R52, R56: 1k; 1005
R54, R55: 3.9k; 1608
R57, R58, R59: 51; 1005
RF1, RF2: 200m; 2012
U8, U10: 1G08DCK; SC70-5
U9: XC6SLX9-TQ144; QFP144-0.5
U11: TC74VHC164FT; TSSOP14
U12: FDG6323L; SC70-6
U13: AE-NJU72501
VR1: 500; VR

Connections:
!ADC1_CS: U9.92 (IO_L41N_GCLK8_1); also elsewhere on the board
!ADC2_CS: U9.17 (IO_L43P_GCLK23_3); also elsewhere on the board
!FPGA_CS: U9.67 (IO_L2P_CMPCLK_2); also elsewhere on the board
!FPGA_INIT: U9.39 (IO_L65P_INIT_B_2); also elsewhere on the board
!FPGA_PROG: R44.2, U8.1 (A), U8.2 (B); also elsewhere on the board
!MOT1_2_DO: U9.93 (IO_L41P_GCLK9_IRDY1_1); also elsewhere on the board
!MOT1_2_LATCH: U9.95 (IO_L40P_GCLK11_1); also elsewhere on the board
!MOT1_FAULT: U9.104 (IO_L1N__VREF_1); also elsewhere on the board
!MOT1_OTW: U9.105 (IO_L1P_1); also elsewhere on the board
!MOT1_RESET_A: U9.101 (IO_L32N_1); also elsewhere on the board
!MOT1_RESET_B: U9.99 (IO_L33N_1); also elsewhere on the board
!MOT1_RESET_C: U9.98 (IO_L34P_1); also elsewhere on the board
!MOT2_FAULT: U9.82 (IO_L45N_1); also elsewhere on the board
!MOT2_OTW: U9.83 (IO_L45P_1); also elsewhere on the board
!MOT2_RESET_A: U9.80 (IO_L46N_1); also elsewhere on the board
!MOT2_RESET_B: U9.78 (IO_L47N_1); also elsewhere on the board
!MOT2_RESET_C: U9.75 (IO_L74P_AWAKE_1); also elsewhere on the board
!MOT3_4_5_DO: U9.21 (IO_L42N_GCLK24_3); also elsewhere on the board
!MOT3_4_5_LATCH: U9.23 (IO_L41N_GCLK26_3); also elsewhere on the board
!MOT3_FAULT: U9.33 (IO_L2P_3); also elsewhere on the board
!MOT3_OTW: U9.34 (IO_L1N_VREF_3); also elsewhere on the board
!MOT3_RESET_A: U9.30 (IO_L36P_3); also elsewhere on the board
!MOT3_RESET_B: U9.27 (IO_L37P_3); also elsewhere on the board
!MOT3_RESET_C: U9.26 (IO_L37N_3); also elsewhere on the board
!MOT4_FAULT: U9.10 (IO_L50P_3); also elsewhere on the board
!MOT4_OTW: U9.11 (IO_L49N_3); also elsewhere on the board
!MOT4_RESET_A: U9.8 (IO_L51P_3); also elsewhere on the board
!MOT4_RESET_B: U9.6 (IO_L52P_3); also elsewhere on the board
!MOT4_RESET_C: U9.5 (IO_L52N_3); also elsewhere on the board
!MOT5_FAULT: U9.141 (IO_L2N_0); also elsewhere on the board
!MOT5_OTW: U9.142 (IO_L2P_0); also elsewhere on the board
!MOT5_RESET_A: U9.139 (IO_L3N_0); also elsewhere on the board
!MOT5_RESET_B: U9.137 (IO_L4N_0); also elsewhere on the board
!MOT5_RESET_C: U9.134 (IO_L34P_GCLK19_0); also elsewhere on the board
!XBEE_CTS: CN7.12 (!CTS!/DIO7), U9.115 (IO_L65P_SCP3_0)
!XBEE_RST: CN7.5 (!RESET), R53.2, U9.123 (IO_L37N_GCLK12_0)
+1V2: C55.2, C56.2, C58.2, C60.2, C62.2, C63.1; also elsewhere on the board
+3V3: C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C57.1, C59.1, C61.1, C64.1, C67.1, CN6.1, CN18.2, FB1.1, R54.2, R55.2, R58.2, R59.2, RF2.2, U8.5 (VCC), U9.4 (VCCO_3), U9.18 (VCCO_3), U9.20 (VCCAUX), U9.31 (VCCO_3), U9.36 (VCCAUX), U9.42 (VCCO_2), U9.53 (VCCAUX), U9.63 (VCCO_2), U9.72 (CMPCS_B_2), U9.76 (VCCO_1), U9.86 (VCCO_1), U9.90 (VCCAUX), U9.103 (VCCO_1), U9.122 (VCCO_0), U9.125 (VCCO_0), U9.129 (VCCAUX), U9.135 (VCCO_0), U10.5 (VCC), U11.1 (A), U11.9 (!CLR), U11.14 (VCC), U13.1 (VIN), U13.5 (EN2), U13.6 (EN1); also elsewhere on the board
+5V: RF1.2; also elsewhere on the board
ADC1_MISO: U9.85 (IO_L43P_GCLK5_1); also elsewhere on the board
ADC1_MOSI: U9.87 (IO_L42N_GCLK6_TRDY1_1); also elsewhere on the board
ADC1_SCLK: U9.88 (IO_L42P_GCLK7_1); also elsewhere on the board
ADC2_MISO: U9.14 (IO_L44N_GCLK20_3); also elsewhere on the board
ADC2_MOSI: U9.15 (IO_L44P_GCLK21_3); also elsewhere on the board
ADC2_SCLK: U9.16 (IO_L43N_GCLK22_IRDY2_3); also elsewhere on the board
BALL_DETECT/BALL_SDA: R56.2, U9.112 (IO_L66P_SCP1_0)
BALL_EN: R60.2, U9.116 (IO_L64N_SCP4_0), U12.5 (EN)
BALL_SCL: R57.2, U9.114 (IO_L65N_SCP2_0)
BUZZER_PWM: C65.1, R45.1, U13.3 (DIN)
EXT1_CE: CN6.2, U9.117 (IO_L64P_SCP5_0)
EXT1_CSN: CN6.3, U9.119 (IO_L63P_SCP7_0)
EXT1_IRQ: CN6.7, U9.132 (IO_L35P_GCLK17_0)
EXT1_MISO: CN6.6, U9.127 (IO_L36P_GCLK15_0)
EXT1_MOSI: CN6.5, U9.124 (IO_L37P_GCLK13_0)
EXT1_SCK: CN6.4, U9.121 (IO_L62P_0)
FPGA_AUX0: CN18.8, U9.69 (IO_L1N_M0_CMPMISO_2); also elsewhere on the board
FPGA_AUX1: CN18.4, U9.64 (IO_L3N_MOSI_CSI_B_MISO0_2); also elsewhere on the board
FPGA_AUX2: CN18.3, U9.48 (IO_L48P_D7_2); also elsewhere on the board
FPGA_CLK: U9.50 (IO_L31N_GCLK30_D15_2); also elsewhere on the board
FPGA_CONF: U10.1 (A); also elsewhere on the board
FPGA_DONE: U9.71 (DONE_2); also elsewhere on the board
FPGA_TCK: P1.1, U9.109 (TCK)
FPGA_TDI: P2.1, U9.110 (TDI)
FPGA_TDO: P3.1, U9.106 (TDO)
FPGA_TMS: P4.1, U9.107 (TMS)
GND: C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.GND, C56.GND, C57.2, C58.GND, C59.2, C60.GND, C61.2, C62.GND, C63.2, C64.2, C65.2, C66.2, C67.2, CN6.8, CN7.10 (GND), CN8.2, CN18.1, LED4.K, LED5.K, LED6.K, LED7.K, LED8.K, LED9.K, LED10.K, R44.1, R53.1, R60.1, U8.3 (GND), U9.3 (GND), U9.13 (GND), U9.25 (GND), U9.49 (GND), U9.54 (GND), U9.68 (GND), U9.73 (SUSPEND), U9.77 (GND), U9.91 (GND), U9.96 (GND), U9.108 (GND), U9.113 (GND), U9.130 (GND), U9.136 (GND), U10.3 (GND), U11.7 (GND), U12.1 (R2), U13.2 (GND), U13.4 (GND); also elsewhere on the board
LED_CLK: U9.131 (IO_L35N_GCLK16_0), U11.8 (CK)
LED_DO: U9.126 (IO_L36N_GCLK14_0), U11.2 (B)
MOT1_2_CLK: U9.94 (IO_L40N_GCLK10_1); also elsewhere on the board
MOT1_2_EN_SENSOR: U9.84 (IO_L43N_GCLK4_1); also elsewhere on the board
MOT1_PWM_A: U9.102 (IO_L32P_1); also elsewhere on the board
MOT1_PWM_B: U9.100 (IO_L33P_1); also elsewhere on the board
MOT1_PWM_C: U9.97 (IO_L34N_1); also elsewhere on the board
MOT1_TEMP: U9.111 (IO_L66N_SCP0_0); also elsewhere on the board
MOT2_PWM_A: U9.81 (IO_L46P_1); also elsewhere on the board
MOT2_PWM_B: U9.79 (IO_L47P_1); also elsewhere on the board
MOT2_PWM_C: U9.74 (IO_L74N_DOUT_BUSY_1); also elsewhere on the board
MOT3_4_5_CLK: U9.22 (IO_L42P_GCLK25_TRDY2_3); also elsewhere on the board
MOT3_4_5_EN_SENSOR: U9.12 (IO_L49P_3); also elsewhere on the board
MOT3_PWM_A: U9.32 (IO_L2N_3); also elsewhere on the board
MOT3_PWM_B: U9.29 (IO_L36N_3); also elsewhere on the board
MOT3_PWM_C: U9.24 (IO_L41P_GCLK27_3); also elsewhere on the board
MOT3_TEMP: U9.35 (IO_L1P_3); also elsewhere on the board
MOT4_PWM_A: U9.9 (IO_L50N_3); also elsewhere on the board
MOT4_PWM_B: U9.7 (IO_L51N_3); also elsewhere on the board
MOT4_PWM_C: U9.2 (IO_L83P_3); also elsewhere on the board
MOT4_TEMP: U9.1 (IO_L83N_VREF_3); also elsewhere on the board
MOT5_CUR_SCL: U9.144 (IO_L1P_HSWAPEN_0); also elsewhere on the board
MOT5_CUR_SDA: U9.143 (IO_L1N_VREF_0); also elsewhere on the board
MOT5_PWM_A: U9.140 (IO_L3P_0); also elsewhere on the board
MOT5_PWM_B: U9.138 (IO_L4P_0); also elsewhere on the board
MOT5_PWM_C: U9.133 (IO_L34N_GCLK18_0); also elsewhere on the board
unnamed: C66.1, CN7.1 (VCC), FB1.2
unnamed: BZ1.1, U13.8 (VO1)
unnamed: U8.4 (Y), U9.37 (PROGRAM_B_2)
unnamed: U9.70 (IO_L1P_CCLK_2), U10.4 (Y)
unnamed: BZ1.2, U13.7 (VO2)
unnamed: CN8.1, R54.1, R56.1
unnamed: CN8.3, R55.1, R57.1, VR1.A
unnamed: CN8.4, U12.2 (OUT), U12.3 (OUT)
unnamed: R58.1, R59.1, VR1.B, VR1.W
unnamed: LED4.A, R46.1
unnamed: R61.1, U12.6 (R1)
unnamed: LED7.A, R49.1
unnamed: LED6.A, R48.1
unnamed: LED5.A, R47.1
unnamed: R61.2, RF1.1, RF2.1, U12.4 (IN)
unnamed: R47.2, U11.12 (QG)
unnamed: LED8.A, R50.1
unnamed: LED9.A, R51.1
unnamed: LED10.A, R52.1
unnamed: R48.2, U11.11 (QF)
unnamed: R49.2, U11.10 (QE)
unnamed: R46.2, U11.13 (QH)
unnamed: R50.2, U11.6 (QD)
unnamed: R51.2, U11.5 (QC)
unnamed: R52.2, U11.4 (QB)
unnamed: R45.2, U11.3 (QA)
unnamed: C62.1, U9.19 (VCCINT)
unnamed: C60.1, U9.28 (VCCINT)
unnamed: C58.1, U9.52 (VCCINT)
unnamed: C56.1, U9.89 (VCCINT)
unnamed: C55.1, U9.128 (VCCINT)
PWR_5V: U9.40 (IO_L64N_D9_2); also elsewhere on the board
SPI_MISO: CN18.7, U9.66 (IO_L2N_CMPMOSI_2); also elsewhere on the board
SPI_MOSI: CN18.6, U9.65 (IO_L3P_D0_DIN_MISO_MISO1_2); also elsewhere on the board
SPI_SCLK: CN18.5, U9.56 (IO_L30P_GCLK1_D13_2), U10.2 (B); also elsewhere on the board
XBEE_RX: CN7.2 (DOUT), U9.118 (IO_L63N_SCP6_0)
XBEE_TX: CN7.3 (DIN/!CONFIG), U9.120 (IO_L62N_VREF_0)

Notes on the sheet:
光センサーの基板によって回路を変える
CN6,18は実装しない
