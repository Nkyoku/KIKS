# Repository Nkyoku/KIKS

File readme.txt:

KIKS
====

KIKS robot's electronics

TerminalBin and Drivers are here.
https://onedrive.live.com/#cid=570A76783C234EE4&id=570A76783C234EE4%21858

## EAGLE design EagleFiles/project/Encoder/Encoder.brd

Parts:
C1: 100n; 1608
C2: 4.7u; 1608
C3: 1u; 1608
CN1: US Digital 4pin; 53261-04
CN2: Host; 504050-0691
CN3: Motor; 52271-11
LED1: Red; 1608
R1: 1.5k; 1608
R2, R3, R4, R5: 51; 1608
U1: AS5145B; SSOP16

Connections:
+5V: C1.1, C3.1, CN1.1, CN3.1, R1.2, U1.16 (VDD5V)
ENC_A: CN1.2, R2.2, R3.2
ENC_B: CN1.4, R4.2, R5.2
GND: C1.2, C2.2, C3.2, CN1.3, CN1.S1, CN1.S2, CN2.S1, CN2.S2, CN3.5, CN3.S1, CN3.S2, U1.7 (VSS), U1.8 (PDIO), U1.10 (CLK), U1.11 (!CS)
HALL_U: CN2.3, CN3.3
HALL_V: CN2.2, CN3.4
HALL_W: CN2.1, CN3.2
MOT_U: CN2.6, CN3.10, CN3.11
MOT_V: CN2.5, CN3.8, CN3.9
MOT_W: CN2.4, CN3.6, CN3.7
unnamed: R2.1, R4.1, U1.3 (DTEST1/A)
unnamed: C2.1, U1.15 (VDD3V3)
unnamed: R3.1, R5.1, U1.4 (DTEST2/B)
unnamed: LED1.K, U1.1 (!MAGINC), U1.2 (!MAGDEC)
unnamed: LED1.A, R1.1

Notes on the sheet:
KIKS2014
Gen.5 Optical Encoder
FUJII NAOMICHI
Designed by
Date
2013/12/26
Revision A

Board: 2 copper layers, 28.0 x 36.0 mm, 13 parts (7 on the bottom side), 15 nets.

## EAGLE design EagleFiles/project/IMU/imu.brd

Parts:
C1, C3, C7, C8: 100n; 1005
C2, C9: 1n; 1005
C4: 1u; 1005
C5: 10u; 1005
C6: 10n; 1005
CN1: External SPI 1; PIN1X8
CN2: External SPI 2; PIN2X4
FB1: FB1608; 1608
LED1: White; 1608
LED2: Red; 1608
Q1: MOS-N-SOT23; SOT23-3
Q2: PNP-SOT23; SOT23-3
R1: 51; 1005
R2, R3, R4, R5, R7, R8, R9: 10k; 1005
R6: 10; 1608
R10: 1.5k; 1005
U1: MPU-6000; QFN24-0.5
U2: TCS34725; FN-6
U3: N25Q512AM; DFN8-1.27
X1: 19.2M; OSC2520

Connections:
!EXT_CS: CN1.3, R3.1, U1.8 (!CS)
!EXT_RST: CN1.2, R2.2, X1.1 (EN)
+3V3: C6.1, C8.1, CN1.1, FB1.1, R3.2, R4.2, R5.2, R6.2, R8.2, U2.1 (VDD), X1.4 (VDD)
+3V3/2: C7.1, CN2.1, R9.2, R10.2, U3.3 (!W!/DQ2), U3.7 (!H!/DQ3), U3.8 (VCC)
AUX_SCL: R4.1, U1.7 (AUX_CL), U2.2 (SCL)
AUX_SDA: R5.1, U1.6 (AUX_DA), U2.6 (SDA)
EXT_INT: CN1.7, U1.12 (INT)
EXT_MISO: CN1.6, U1.9 (AD0/SDO)
EXT_MOSI: CN1.5, U1.24 (SDA/SDI)
EXT_SCLK: CN1.4, U1.23 (SCL/SCLK)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, CN1.8, CN2.2, Q1.2 (S), Q2.3 (C), R2.1, R7.2, U1.11 (FSYNC), U1.18 (GND), U1.PAD (GND), U2.3 (GND), U3.4 (GND), U3.PAD (GND), X1.2 (GND)
MCU_AUX0: CN2.7
MCU_AUX1: CN2.3, R9.1, U3.1 (!S)
MCU_AUX2: CN2.4, LED2.K, Q1.1 (G), R7.1
MCU_MISO: CN2.8, U3.2 (SO/DQ1)
MCU_MOSI: CN2.5, U3.5 (SI/DQ0)
MCU_SCLK: CN2.6, U3.6 (C)
unnamed: C2.1, C9.1, U1.20 (CPOUT)
unnamed: C3.1, U1.10 (REGOUT)
unnamed: C1.1, C4.1, C5.1, FB1.2, U1.13 (VDD)
unnamed: R1.2, X1.3 (OUT)
unnamed: R1.1, U1.1 (CLKIN)
unnamed: LED1.A, R6.1
unnamed: Q2.1 (B), R8.1, U2.5 (INT)
unnamed: LED1.K, Q1.3 (D), Q2.2 (E)
unnamed: LED2.A, R10.1

Notes on the sheet:
KIKS2013
Gen.5's IMU
FUJII NAOMICHI
Created by
Date
2013/08/11
MCU_AUX0はコンフィグレーション中は駆動されない MCU_AUX1, MCU_AUX2は未使用
LEDのスペクトルに注意

Board: 2 copper layers, 22.0 x 41.0 mm, 30 parts (2 on the bottom side), 25 nets.

## EAGLE design EagleFiles/project/AP Controller/ap.brd

Parts:
C1, C2, C19, C20, C21: 100n; 1608
C3, C17: 1u; 1608
C4, C11: 10u; 2012
C5, C6, C7, C8, C9, C10, C12, C13, C14, C15, C18, C22, C23: 100n; 1005
C16: 10n; 1005
CN1, CN2: USB-MINIB-SMT
CN3: XBEE-SMT
D1: CMS01; 3-4E1A
FB1, FB2: 600; 1608
J1: CN-JTAG; PIN2X5
LED1: Power; LED1608
LED2: Transaction; LED1608
LED3: Independent; LED1608
LED4: DV1; LED1608
LED5: DV2; LED1608
LED6: DV3; LED1608
LED7: DV4; LED1608
LED8: DV5; LED1608
LED9: DV6; LED1608
LED10, LED11: ACSC02
LED12: X_ON; LED1608
LED13: X_AS; LED1608
LED14: X_RS; LED1608
LED15: Error; LED1608
LED16: DV_WRN; LED1608
LED17: DV_ERR; LED1608
R1, R18: 1M; 1608
R2, R3, R19, R20: 22; 1608
R4, R5, R6, R8, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39: 10k; 1005
R7, R21, R22: R1608; 1608
R15, R16, R17: 1k; 1608
RA1, RA2, RA3, RA4: 1k; 1005-A4
RA5, RA6, RA7: RA4; 1005-A4
SW0: Reset; TACT4P-SMT6660
SW1: Left; TACT4P-SMT-6660
SW2: Up; TACT4P-SMT-6660
SW3: Right; TACT4P-SMT-6660
SW4: Down; TACT4P-SMT-6660
SW5: ROL; TACT4P-SMT-4735R
SW6: ROR; TACT4P-SMT-4735R
SW7: FN1; TACT4P-SMT-6660
SW8: FN2; TACT4P-SMT-6660
SW9: FN3; TACT4P-SMT-6660
SW10: FN4; TACT4P-SMT-6660
SW11: FN5; TACT4P-SMT-6660
SW12: FN6; TACT4P-SMT-6660
SW13: FN7; TACT4P-SMT-4735R
SW14: FN8; TACT4P-SMT-4735R
U1: MCP1700T-33; SOT23-3
U2: AT32UC3B164-AU; QFP48-0.5
U3: FT232RL; SSOP28
U4, U5, U6: TC74VHC164FT; TSSOP14
U7, U8: TC74VHC165FT; TSSOP16
X1: 24MHz; OSC2520

Connections:
!LED_DV1: LED4.A, U4.3 (QA)
!LED_DV2: LED5.A, U4.4 (QB)
!LED_DV3: LED6.A, U4.5 (QC)
!LED_DV4: LED7.A, U4.6 (QD)
!LED_DV5: LED8.A, U4.13 (QH), U5.1 (A)
!LED_DV6: LED9.A, U4.12 (QG)
!LED_DVERR: LED17.A, U4.10 (QE)
!LED_DVWRN: LED16.A, U4.11 (QF)
!LED_ERR: LED15.A, U2.10 (PA06/AD3/INT1/USART1-DSR)
!LED_IND: LED3.A, U2.9 (PA05/AD2/INT0/USART1-DCD)
!LED_PWR: LED1.A, U2.7 (PA03/AD0/GCLK0/USB_ID)
!LED_TRC: LED2.A, U2.8 (PA04/AD1/GCLK1/USB_VBOF)
!MCU_RST: SW0.B1, U2.47 (!RESET)
!SR_CL: R4.2, U2.26 (PA14/PWM3/INT2/SPI0-MOSI), U4.9 (!CLR), U5.9 (!CLR), U6.9 (!CLR), U7.1 (S/!L), U8.1 (S/!L)
!X_CTS: CN3.12 (!CTS!/DIO7), U2.20 (PA09/SCL/SPI0-NPCS2/USART1-CTS)
!X_DTR: CN3.9 (!DTR!/SLEEP_RQ/DIO8), U2.29 (PA17/TC-CLK2/SPI0-SCK/SPI0-NPCS1)
!X_RST: CN3.5 (!RESET), R5.2, U2.34 (PA22/TC-B1/PWM6/TRIGGER)
!X_RTS: CN3.16 (!RTS!/DIO6), U2.21 (PA10/SDA/SPI0-NPCS3/USART1-RTS)
+1V8: C11.1, C12.1, C13.1, C14.1, C15.1, U2.6 (VDDCORE), U2.16 (VDDOUT), U2.18 (VDDCORE), U2.41 (VDDPLL), U2.42 (VDDCORE)
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C16.1, C18.1, C22.1, C23.1, FB2.1, J1.4 (VCC), R6.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, U1.2 (VO), U2.14 (ADVREF), U2.15 (VDDANA), U2.17 (VDDIN), U2.24 (VDDIO), U2.36 (VDDIO), U2.40 (VBUS), U2.48 (VDDIO), U4.2 (B), U4.14 (VCC), U5.2 (B), U5.14 (VCC), U6.2 (B), U6.14 (VCC), U7.16 (VCC), U8.16 (VCC), X1.1 (EN), X1.4 (VDD)
+5V: C3.1, FB1.2, U1.3 (VI)
CLK: U2.30 (PA18/XIN0/PWM5/USART0-RXD/SPI0-MISO), X1.3 (OUT)
D+: CN1.3 (D+), R2.1
D-: CN1.2 (D-), R3.1
DBG_D+: CN2.3 (D+), R20.1
DBG_D-: CN2.2 (D-), R19.1
DBG_RX: R21.2, U2.32 (PA20/TC-CLK0/USART1-CLK/USART2-RXD)
DBG_TX: R22.2, U2.33 (PA21/TC-A1/PWM2/USART2-TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, CN1.5 (GND), CN2.5 (GND), CN3.10 (GND), J1.2 (GND), J1.10 (GND), LED10.3 (K), LED10.8 (K), LED11.3 (K), LED11.8 (K), R1.1, R4.1, R5.1, R7.2, R8.1, R15.1, R16.1, R17.1, R18.1, RA5.A1 (1), RA5.B1 (1), RA5.C1 (1), RA5.D1 (1), RA6.A1 (1), RA6.B1 (1), RA6.C1 (1), RA6.D1 (1), RA7.A1 (1), RA7.B1 (1), RA7.C1 (1), RA7.D1 (1), SW0.A1, SW0.A2, SW1.B1, SW1.B2, SW2.B1, SW2.B2, SW3.A1, SW3.A2, SW4.B1, SW4.B2, SW5.A1, SW5.A2, SW6.A1, SW6.A2, SW7.B1, SW7.B2, SW8.B1, SW8.B2, SW9.A1, SW9.A2, SW10.A1, SW10.A2, SW11.A1, SW11.A2, SW12.A1, SW12.A2, SW13.A1, SW13.A2, SW14.A1, SW14.A2, U1.1 (GND), U2.1 (GND), U2.13 (GNDANA), U2.19 (GND), U2.37 (GND), U3.7 (GND), U3.18 (GND), U3.21 (GND), U3.25 (AGND), U3.26 (TEST), U4.7 (GND), U5.7 (GND), U6.7 (GND), U7.8 (GND), U7.10 (SI), U7.15 (CKINH), U8.8 (GND), U8.10 (SI), U8.15 (CKINH), X1.2 (GND)
unnamed: R2.2, U2.38 (DP)
unnamed: C1.1, CN1.S1, R1.2
unnamed: R21.1, U3.1 (TXD)
unnamed: R3.2, U2.39 (DM)
unnamed: LED10.6 (B), RA2.A2 (2)
unnamed: CN3.14 (VREF), R7.1
unnamed: LED10.7 (A), RA2.B2 (2)
unnamed: J1.1 (TCK), R6.1, U2.2 (TCK)
unnamed: J1.9 (TDI), U2.3 (PA00/TDI)
unnamed: LED9.C, RA7.B2 (2)
unnamed: LED10.9 (F), RA2.C2 (2)
unnamed: LED2.C, RA5.B2 (2)
unnamed: LED1.C, RA5.A2 (2)
unnamed: LED4.C, RA6.A2 (2)
unnamed: LED5.C, RA6.B2 (2)
unnamed: LED6.C, RA6.C2 (2)
unnamed: R22.1, U3.5 (RXD)
unnamed: LED7.C, RA6.D2 (2)
unnamed: LED8.C, RA7.A2 (2)
unnamed: LED12.C, R15.2
unnamed: LED13.C, R16.2
unnamed: LED14.C, R17.2
unnamed: R19.2, U3.16 (DM)
unnamed: R20.2, U3.15 (DP)
unnamed: C21.1, U3.4 (VCCIO), U3.17 (3V3OUT)
unnamed: CN2.1 (VBUS), D1.A
unnamed: J1.3 (TDO), U2.4 (PA01/TDO)
unnamed: C19.1, CN2.S3, R18.2
unnamed: LED10.10 (G), RA2.D2 (2)
unnamed: LED10.5 (DP), RA1.A2 (2)
unnamed: LED15.C, RA5.D2 (2)
unnamed: RA1.A1 (1), U5.3 (QA)
unnamed: C17.1, CN3.1 (VCC), FB2.2
unnamed: LED3.C, RA5.C2 (2)
unnamed: LED10.4 (C), RA1.B2 (2)
unnamed: LED10.2 (D), RA1.C2 (2)
unnamed: LED10.1 (E), RA1.D2 (2)
unnamed: LED11.10 (G), RA3.D2 (2)
unnamed: LED11.9 (F), RA3.C2 (2)
unnamed: LED11.7 (A), RA3.B2 (2)
unnamed: LED11.6 (B), RA3.A2 (2)
unnamed: LED11.1 (E), RA4.D2 (2)
unnamed: LED16.C, RA7.C2 (2)
unnamed: RA1.B1 (1), U5.4 (QB)
unnamed: RA1.C1 (1), U5.5 (QC)
unnamed: RA1.D1 (1), U5.6 (QD)
unnamed: RA2.A1 (1), U5.10 (QE)
unnamed: RA2.B1 (1), U5.11 (QF)
unnamed: RA2.C1 (1), U5.12 (QG)
unnamed: RA2.D1 (1), U5.13 (QH), U6.1 (A)
unnamed: LED11.2 (D), RA4.C2 (2)
unnamed: LED11.4 (C), RA4.B2 (2)
unnamed: LED11.5 (DP), RA4.A2 (2)
unnamed: RA3.A1 (1), U6.3 (QA)
unnamed: RA3.B1 (1), U6.4 (QB)
unnamed: RA3.C1 (1), U6.5 (QC)
unnamed: RA3.D1 (1), U6.6 (QD)
unnamed: RA4.A1 (1), U6.10 (QE)
unnamed: RA4.B1 (1), U6.11 (QF)
unnamed: RA4.C1 (1), U6.12 (QG)
unnamed: RA4.D1 (1), U6.13 (QH)
unnamed: LED17.C, RA7.D2 (2)
unnamed: J1.5 (TMS), U2.5 (PA02/TMS)
SR_CLK: R8.2, U2.25 (PA13/PWM2/NMI/USART0-CLK), U4.8 (CK), U5.8 (CK), U6.8 (CK), U7.2 (CK), U8.2 (CK)
SR_DI1: U2.28 (PA16/PWM4/TC-CLK1/SPI0-NPCS0), U7.7 (!QH)
SR_DI2: U2.23 (PA12/XOUT32/PWM1/TC-B2/USART0-CTS), U8.9 (QH)
SR_DO: U2.27 (PA15/PWM4/USART2-CLK/SPI0-SCK), U4.1 (A)
SW1: R36.1, SW1.A2, U8.3 (E)
SW2: R37.1, SW2.A1, U8.4 (F)
SW3: R39.1, SW3.B2, U8.6 (H)
SW4: R38.1, SW4.A2, U8.5 (G)
SW5: SW5.B1, U2.46 (PA27/TC-B0/USB_VBOF/USART2-RXD)
SW6: R30.1, SW6.B2, U7.13 (C)
SW7: R34.1, SW7.A2, U7.5 (G)
SW8: R32.1, SW8.A2, U7.3 (E)
SW9: R35.1, SW9.B2, U7.6 (H)
SW10: R33.1, SW10.B2, U7.4 (F)
SW11: R29.1, SW11.B2, U7.12 (B)
SW12: R28.1, SW12.B2, U7.11 (A)
SW13: SW13.B1, U2.45 (PA26/TC-A0/USB_ID/USART2-TXD)
SW14: R31.1, SW14.B1, U7.14 (D)
VBUS: C2.1, C20.1, CN1.1 (VBUS), D1.C, FB1.1, U3.20 (VCC)
X_ASSOC: CN3.15 (ASSOC/DIO5), LED13.A
X_COMBTN: CN3.20 (COM_BTN/AD0/DIO0)
X_ON: CN3.13 (ON/!SLEEP), LED12.A
X_RSSI: CN3.6 (RSSI/PWM/DIO10), LED14.A
X_RX: CN3.2 (DOUT), U2.43 (PA24/INT4/USART1-RXD/SPI0-NPCS0)
X_TX: CN3.3 (DIN/!CONFIG), U2.35 (PA23/INT3/USART1-TXD/SPI0-NPCS1)

Board: 2 copper layers, 100.0 x 58.0 mm, 106 parts (4 on the bottom side), 116 nets.

## EAGLE design EagleFiles/project/SerialKey/SerialKey.brd

Parts:
C1, C10, C11, C12, C15, C16, C18, C19, C20, C21, C24, C26: 100n; 1005
C2: 47u; 3216
C3, C5, C13: 1u; 1005
C4, C6: 22u; 2012
C7, C8: 33p; 1608
C9, C14, C17, C23, C25: 10u; 1608
CN1: USB-A-PLUG
CN2: XBEE; XBEE-TH-NOSILK
CN3: PIN1X8
FB1, FB2, FB3: FB1608; 1608
LED1: RX; 1608
LED2: TX; 1608
LED3: VSMY2850RG; VISHAY-RGW
R1, R2: 1k; 1005
R3: 12k; 1608
R6: 10k; 1005
R12: 22; 1005
T1: VOUT; TERMINAL
T2, T10: GND; TERMINAL
T3: LED; TERMINAL
T4, T12: VCC; TERMINAL
T5, T7, T13: A; TERMINAL
T6, T8, T14: K; TERMINAL
T9: SDA; TERMINAL
T11: SCL; TERMINAL
U1, U2: MCP1700T-33; SOT23-3
U3: FT2232HL; QFP64-0.5
U6: S6809-SMD; S6809
U7: VCNL4020
X1: 12M; HC49

Connections:
!EXT_CS: CN3.3, U3.19 (ADBUS3)
!XBEE_CTS: CN2.12 (!CTS!/DIO7), U3.41 (BDBUS3)
!XBEE_RTS: CN2.16 (!RTS!/DIO6), U3.40 (BDBUS2)
+3V3: C4.1, C18.1, C19.1, C20.1, C21.1, FB2.1, FB3.1, R1.2, R2.2, R6.1, U1.2 (VO), U3.14 (!RESET), U3.20 (VCCIO), U3.31 (VCCIO), U3.42 (VCCIO), U3.50 (VREGIN), U3.56 (VCCIO)
+3V3/2: C6.1, CN2.1 (VCC), CN3.1, U2.2 (VO)
BALL_GND: C13.2, T2.1, U6.2 (GND)
BALL_LEDA: LED3.A, T7.1
BALL_LEDC: LED3.K, T8.1
BALL_SINK: T6.1, U6.3 (LED)
BALL_VCC: C13.1, T4.1, U6.4 (VCC)
BALL_VOUT: T1.1, U6.1 (VOUT)
EXT_CE: CN3.2, U3.22 (ADBUS5)
EXT_IRQ: CN3.7, U3.21 (ADBUS4)
EXT_MISO: CN3.6, U3.18 (ADBUS2)
EXT_MOSI: CN3.5, U3.17 (ADBUS1)
EXT_SCLK: CN3.4, U3.16 (ADBUS0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, CN1.4 (GND), CN1.S1, CN1.S2, CN2.10 (GND), CN3.8, R3.1, U1.1 (GND), U2.1 (GND), U3.1 (GND), U3.5 (GND), U3.10 (AGND), U3.11 (GND), U3.13 (TEST), U3.15 (GND), U3.25 (GND), U3.35 (GND), U3.47 (GND), U3.51 (GND)
unnamed: C1.1, CN1.1 (VBUS), FB1.1
unnamed: R3.2, U3.6 (REF)
unnamed: C9.1, C10.1, C11.1, C12.1, U3.12 (VCORE), U3.37 (VCORE), U3.49 (VREGOUT), U3.64 (VCORE)
unnamed: LED1.A, R1.1
unnamed: LED2.A, R2.1
unnamed: LED1.K, U3.54 (BCBUS3)
unnamed: LED2.K, U3.55 (BCBUS4)
unnamed: C23.1, C24.1, FB2.2, U3.4 (VPHY)
unnamed: C25.1, C26.1, FB3.2, U3.9 (VPLL)
unnamed: T3.1, T5.1
unnamed: R6.2, U3.61 (EEDATA)
unnamed: C14.1, C15.1, R12.2, U7.5 (VDD)
unnamed: C7.1, U3.2 (OSCI), X1.1 (A)
unnamed: C8.1, U3.3 (OSCO), X1.2 (B)
PROX_GND: C14.2, C15.2, C16.2, C17.2, T10.1, U7.8 (GND), U7.9 (GND)
PROX_K: T14.1, U7.10 (IR_C)
PROX_SCL: T11.1, U7.4 (SCL)
PROX_SDA: T9.1, U7.2 (SDA)
PROX_VCC: C16.1, C17.1, R12.1, T12.1, T13.1, U7.1 (IR_A)
USB_D+: CN1.3 (D+), U3.8 (DP)
USB_D-: CN1.2 (D-), U3.7 (DM)
VBUS: C2.1, C3.1, C5.1, FB1.2, U1.3 (VI), U2.3 (VI)
XBEE_RX: CN2.2 (DOUT), U3.39 (BDBUS1)
XBEE_TX: CN2.3 (DIN/!CONFIG), U3.38 (BDBUS0)

Notes on the sheet:
KIKS2013
Serial / IR Debug Interface
FUJII NAOMICHI
Schemed by
Date
2012/12/12

Board: 2 copper layers, 50.0 x 40.0 mm, 59 parts (13 on the bottom side), 41 nets.
