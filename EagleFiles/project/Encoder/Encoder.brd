# Repository Nkyoku/KIKS (continued)

## EAGLE design EagleFiles/project/BaseBoard5A/BaseBoard5.brd (continued)

Parts:
C68, C83, C98, C113: 100u; E2.5-6.3
C69, C70, C71, C73, C84, C85, C86, C88, C99, C100, C101, C103, C114, C115, C116, C118: 1u; 1608
C72, C81, C82, C87, C96, C97, C102, C111, C112, C117, C126, C127: 100n; 1005
C74, C75, C76, C77, C78, C79, C89, C90, C91, C92, C93, C94, C104, C105, C106, C107, C108, C109, C119, C120, C121, C122, C123, C124: 100n; 1608
C80, C95, C110, C125: 220u; E3.5-8
C128, C129, C130, C131: 1u; 1005
CN9, CN11, CN13, CN15: EC45FLAT2; MOTOR_COMPLEX2
CN10: Motor1; 53375-04
CN12: Motor2; 53375-04
CN14: Motor3; 53375-04
CN16: Motor4; 53375-04
R62, R66, R70, R74: 33k; 1608
R63, R67, R71, R75: 1; 1005
R64, R65, R68, R69, R72, R73, R76, R77: 5m; 3216
R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97: 100k; 1005
RA2, RA3, RA4, RA5, RA6, RA7, RA8, RA9: 51; 1005-A4
U14, U17, U20, U23: DRV8332; HSSOP36
U15, U16, U18, U19, U21, U22, U24, U25: INA214; SC70-6

Connections:
!MOT1_FAULT: RA2.B1 (1); also elsewhere on the board
!MOT1_HU_5: CN9.1.3 (HU), CN9.2.2 (HU), R80.2; also elsewhere on the board
!MOT1_HV_5: CN9.1.4 (HV), CN9.2.3 (HV), R81.2; also elsewhere on the board
!MOT1_HW_5: CN9.1.2 (HW), CN9.2.4 (HW), R82.2; also elsewhere on the board
!MOT1_OTW: RA2.A1 (1); also elsewhere on the board
!MOT1_RESET_A: RA2.D1 (1); also elsewhere on the board
!MOT1_RESET_B: RA3.B1 (1); also elsewhere on the board
!MOT1_RESET_C: RA3.C1 (1); also elsewhere on the board
!MOT2_FAULT: RA4.B1 (1); also elsewhere on the board
!MOT2_HU_5: CN11.1.3 (HU), CN11.2.2 (HU), R85.2; also elsewhere on the board
!MOT2_HV_5: CN11.1.4 (HV), CN11.2.3 (HV), R86.2; also elsewhere on the board
!MOT2_HW_5: CN11.1.2 (HW), CN11.2.4 (HW), R87.2; also elsewhere on the board
!MOT2_OTW: RA4.A1 (1); also elsewhere on the board
!MOT2_RESET_A: RA4.D1 (1); also elsewhere on the board
!MOT2_RESET_B: RA5.B1 (1); also elsewhere on the board
!MOT2_RESET_C: RA5.C1 (1); also elsewhere on the board
!MOT3_FAULT: RA6.B1 (1); also elsewhere on the board
!MOT3_HU_5: CN13.1.3 (HU), CN13.2.2 (HU), R90.2; also elsewhere on the board
!MOT3_HV_5: CN13.1.4 (HV), CN13.2.3 (HV), R91.2; also elsewhere on the board
!MOT3_HW_5: CN13.1.2 (HW), CN13.2.4 (HW), R92.2; also elsewhere on the board
!MOT3_OTW: RA6.A1 (1); also elsewhere on the board
!MOT3_RESET_A: RA6.D1 (1); also elsewhere on the board
!MOT3_RESET_B: RA7.B1 (1); also elsewhere on the board
!MOT3_RESET_C: RA7.C1 (1); also elsewhere on the board
!MOT4_FAULT: RA8.B1 (1); also elsewhere on the board
!MOT4_HU_5: CN15.1.3 (HU), CN15.2.2 (HU), R95.2; also elsewhere on the board
!MOT4_HV_5: CN15.1.4 (HV), CN15.2.3 (HV), R96.2; also elsewhere on the board
!MOT4_HW_5: CN15.1.2 (HW), CN15.2.4 (HW), R97.2; also elsewhere on the board
!MOT4_OTW: RA8.A1 (1); also elsewhere on the board
!MOT4_RESET_A: RA8.D1 (1); also elsewhere on the board
!MOT4_RESET_B: RA9.B1 (1); also elsewhere on the board
!MOT4_RESET_C: RA9.C1 (1); also elsewhere on the board
+5V/2: C128.1, C129.1, CN9.1.1 (VCC), CN9.2.8 (VCC), CN10.4, CN11.1.1 (VCC), CN11.2.8 (VCC), CN12.4; also elsewhere on the board
+5V/3: C130.1, C131.1, CN13.1.1 (VCC), CN13.2.8 (VCC), CN14.4, CN15.1.1 (VCC), CN15.2.8 (VCC), CN16.4; also elsewhere on the board
+12V: C68.P, C69.1, C70.1, C71.1, C73.1, C83.P, C84.1, C85.1, C86.1, C88.1, C98.P, C99.1, C100.1, C101.1, C103.1, C113.P, C114.1, C115.1, C116.1, C118.1, U14.1 (GVDD_B), U14.17 (VDD), U14.18 (GVDD_C), U14.19 (GVDD_C), U14.36 (GVDD_A), U17.1 (GVDD_B), U17.17 (VDD), U17.18 (GVDD_C), U17.19 (GVDD_C), U17.36 (GVDD_A), U20.1 (GVDD_B), U20.17 (VDD), U20.18 (GVDD_C), U20.19 (GVDD_C), U20.36 (GVDD_A), U23.1 (GVDD_B), U23.17 (VDD), U23.18 (GVDD_C), U23.19 (GVDD_C), U23.36 (GVDD_A); also elsewhere on the board
GND: C68.N, C69.2, C70.2, C71.2, C73.2, C77.2, C78.2, C79.2, C80.N, C81.2, C82.2, C83.N, C84.2, C85.2, C86.2, C88.2, C92.2, C93.2, C94.2, C95.N, C96.2, C97.2, C98.N, C99.2, C100.2, C101.2, C103.2, C107.2, C108.2, C109.2, C110.N, C111.2, C112.2, C113.N, C114.2, C115.2, C116.2, C118.2, C122.2, C123.2, C124.2, C125.N, C126.2, C127.2, C128.2, C129.2, C130.2, C131.2, CN9.1.5 (GND), CN9.2.1 (GND), CN9.S1, CN9.S2, CN10.2, CN11.1.5 (GND), CN11.2.1 (GND), CN11.S1, CN11.S2, CN12.2, CN13.1.5 (GND), CN13.2.1 (GND), CN13.S1, CN13.S2, CN14.2, CN15.1.5 (GND), CN15.2.1 (GND), CN15.S1, CN15.S2, CN16.2, R63.1, R67.1, R71.1, R75.1, R78.1, R79.1, R80.1, R81.1, R82.1, R83.1, R84.1, R85.1, R86.1, R87.1, R88.1, R89.1, R90.1, R91.1, R92.1, R93.1, R94.1, R95.1, R96.1, R97.1, U14.8 (GND), U14.23 (GND_C), U14.24 (GND), U14.25 (GND), U14.31 (GND_B), U14.32 (GND_A), U15.2 (GND), U16.2 (GND), U17.8 (GND), U17.23 (GND_C), U17.24 (GND), U17.25 (GND), U17.31 (GND_B), U17.32 (GND_A), U18.2 (GND), U19.2 (GND), U20.8 (GND), U20.23 (GND_C), U20.24 (GND), U20.25 (GND), U20.31 (GND_B), U20.32 (GND_A), U21.2 (GND), U22.2 (GND), U23.8 (GND), U23.23 (GND_C), U23.24 (GND), U23.25 (GND), U23.31 (GND_B), U23.32 (GND_A), U24.2 (GND), U25.2 (GND); also elsewhere on the board
MOT1_2_5V: C81.1, C82.1, C96.1, C97.1, U15.3 (V+), U16.3 (V+), U18.3 (V+), U19.3 (V+); also elsewhere on the board
MOT1_2_CUR_REF: U15.1 (REF), U16.1 (REF), U18.1 (REF), U19.1 (REF); also elsewhere on the board
MOT1_A_5: CN10.3, R78.2; also elsewhere on the board
MOT1_B_5: CN10.1, R79.2; also elsewhere on the board
MOT1_CUR_V: U15.6 (OUT); also elsewhere on the board
MOT1_CUR_W: U16.6 (OUT); also elsewhere on the board
MOT1_GND: C72.2, R62.1, R63.2, U14.9 (AGND), U14.12 (M2)
MOT1_OUT_U: C74.2, CN9.1.10 (U), CN9.1.11 (U), CN9.2.5 (U), U14.33 (OUT_A)
MOT1_OUT_V: CN9.1.8 (V), CN9.1.9 (V), CN9.2.6 (V), R64.2, U15.5 (VIN-)
MOT1_OUT_W: CN9.1.6 (W), CN9.1.7 (W), CN9.2.7 (W), R65.2, U16.5 (VIN-)
MOT1_PWM_A: RA2.C1 (1); also elsewhere on the board
MOT1_PWM_B: RA3.A1 (1); also elsewhere on the board
MOT1_PWM_C: RA3.D1 (1); also elsewhere on the board
MOT2_A_5: CN12.3, R83.2; also elsewhere on the board
MOT2_B_5: CN12.1, R84.2; also elsewhere on the board
MOT2_CUR_U: U18.6 (OUT); also elsewhere on the board
MOT2_CUR_V: U19.6 (OUT); also elsewhere on the board
MOT2_GND: C87.2, R66.1, R67.2, U17.9 (AGND), U17.12 (M2)
MOT2_OUT_U: CN11.1.10 (U), CN11.1.11 (U), CN11.2.5 (U), R68.2, U18.4 (VIN+)
MOT2_OUT_V: CN11.1.8 (V), CN11.1.9 (V), CN11.2.6 (V), R69.2, U19.4 (VIN+)
MOT2_OUT_W: C91.2, CN11.1.6 (W), CN11.1.7 (W), CN11.2.7 (W), U17.22 (OUT_C)
MOT2_PWM_A: RA4.C1 (1); also elsewhere on the board
MOT2_PWM_B: RA5.A1 (1); also elsewhere on the board
MOT2_PWM_C: RA5.D1 (1); also elsewhere on the board
MOT3_4_5V: C111.1, C112.1, C126.1, C127.1, U21.3 (V+), U22.3 (V+), U24.3 (V+), U25.3 (V+); also elsewhere on the board
MOT3_4_CUR_REF: U21.1 (REF), U22.1 (REF), U24.1 (REF), U25.1 (REF); also elsewhere on the board
MOT3_A_5: CN14.3, R88.2; also elsewhere on the board
MOT3_B_5: CN14.1, R89.2; also elsewhere on the board
MOT3_CUR_V: U21.6 (OUT); also elsewhere on the board
MOT3_CUR_W: U22.6 (OUT); also elsewhere on the board
MOT3_GND: C102.2, R70.1, R71.2, U20.9 (AGND), U20.12 (M2)
MOT3_OUT_U: C104.2, CN13.1.10 (U), CN13.1.11 (U), CN13.2.5 (U), U20.33 (OUT_A)
MOT3_OUT_V: CN13.1.8 (V), CN13.1.9 (V), CN13.2.6 (V), R72.2, U21.5 (VIN-)
MOT3_OUT_W: CN13.1.6 (W), CN13.1.7 (W), CN13.2.7 (W), R73.2, U22.5 (VIN-)
MOT3_PWM_A: RA6.C1 (1); also elsewhere on the board
MOT3_PWM_B: RA7.A1 (1); also elsewhere on the board
MOT3_PWM_C: RA7.D1 (1); also elsewhere on the board
MOT4_A_5: CN16.3, R93.2; also elsewhere on the board
MOT4_B_5: CN16.1, R94.2; also elsewhere on the board
MOT4_CUR_U: U24.6 (OUT); also elsewhere on the board
MOT4_CUR_V: U25.6 (OUT); also elsewhere on the board
MOT4_GND: C117.2, R74.1, R75.2, U23.9 (AGND), U23.12 (M2)
MOT4_OUT_U: CN15.1.10 (U), CN15.1.11 (U), CN15.2.5 (U), R76.2, U24.4 (VIN+)
MOT4_OUT_V: CN15.1.8 (V), CN15.1.9 (V), CN15.2.6 (V), R77.2, U25.4 (VIN+)
MOT4_OUT_W: C121.2, CN15.1.6 (W), CN15.1.7 (W), CN15.2.7 (W), U23.22 (OUT_C)
MOT4_PWM_A: RA8.C1 (1); also elsewhere on the board
MOT4_PWM_B: RA9.A1 (1); also elsewhere on the board
MOT4_PWM_C: RA9.D1 (1); also elsewhere on the board
unnamed: R62.2, U14.7 (OC_ADJ)
unnamed: C74.1, U14.35 (BST_A)
unnamed: C75.2, R64.1, U14.30 (OUT_B), U15.4 (VIN+)
unnamed: R70.2, U20.7 (OC_ADJ)
unnamed: C75.1, U14.28 (BST_B)
unnamed: C76.1, U14.20 (BST_C)
unnamed: C72.1, U14.10 (VREG), U14.11 (M3), U14.13 (M1)
unnamed: C89.2, R68.1, U17.33 (OUT_A), U18.5 (VIN-)
unnamed: R66.2, U17.7 (OC_ADJ)
unnamed: C89.1, U17.35 (BST_A)
unnamed: C90.1, U17.28 (BST_B)
unnamed: C90.2, R69.1, U17.30 (OUT_B), U19.5 (VIN-)
unnamed: C91.1, U17.20 (BST_C)
unnamed: C87.1, U17.10 (VREG), U17.11 (M3), U17.13 (M1)
unnamed: C106.2, R73.1, U20.22 (OUT_C), U22.4 (VIN+)
unnamed: C76.2, R65.1, U14.22 (OUT_C), U16.4 (VIN+)
unnamed: RA3.C2 (2), U14.15 (!RESET_C)
unnamed: RA3.B2 (2), U14.14 (!RESET_B)
unnamed: RA2.D2 (2), U14.5 (!RESET_A)
unnamed: RA3.D2 (2), U14.16 (PWM_C)
unnamed: RA3.A2 (2), U14.6 (PWM_B)
unnamed: RA2.C2 (2), U14.4 (PWM_A)
unnamed: RA2.B2 (2), U14.3 (!FAULT)
unnamed: RA2.A2 (2), U14.2 (!OTW)
unnamed: RA4.A2 (2), U17.2 (!OTW)
unnamed: RA4.B2 (2), U17.3 (!FAULT)
unnamed: RA4.C2 (2), U17.4 (PWM_A)
unnamed: RA5.A2 (2), U17.6 (PWM_B)
unnamed: RA5.D2 (2), U17.16 (PWM_C)
unnamed: RA4.D2 (2), U17.5 (!RESET_A)
unnamed: RA5.B2 (2), U17.14 (!RESET_B)
unnamed: RA5.C2 (2), U17.15 (!RESET_C)
unnamed: C104.1, U20.35 (BST_A)
unnamed: C105.1, U20.28 (BST_B)
unnamed: C105.2, R72.1, U20.30 (OUT_B), U21.4 (VIN+)
unnamed: C106.1, U20.20 (BST_C)
unnamed: C102.1, U20.10 (VREG), U20.11 (M3), U20.13 (M1)
unnamed: RA6.A2 (2), U20.2 (!OTW)
unnamed: RA6.B2 (2), U20.3 (!FAULT)
unnamed: RA6.C2 (2), U20.4 (PWM_A)
unnamed: RA7.A2 (2), U20.6 (PWM_B)
unnamed: RA7.D2 (2), U20.16 (PWM_C)
unnamed: RA6.D2 (2), U20.5 (!RESET_A)
unnamed: RA7.B2 (2), U20.14 (!RESET_B)
unnamed: RA7.C2 (2), U20.15 (!RESET_C)
unnamed: C119.2, R76.1, U23.33 (OUT_A), U24.5 (VIN-)
unnamed: R74.2, U23.7 (OC_ADJ)
unnamed: C119.1, U23.35 (BST_A)
unnamed: C120.1, U23.28 (BST_B)
unnamed: C120.2, R77.1, U23.30 (OUT_B), U25.5 (VIN-)
unnamed: C121.1, U23.20 (BST_C)
unnamed: C117.1, U23.10 (VREG), U23.11 (M3), U23.13 (M1)
unnamed: RA8.A2 (2), U23.2 (!OTW)
unnamed: RA8.B2 (2), U23.3 (!FAULT)
unnamed: RA8.C2 (2), U23.4 (PWM_A)
unnamed: RA9.A2 (2), U23.6 (PWM_B)
unnamed: RA9.D2 (2), U23.16 (PWM_C)
unnamed: RA8.D2 (2), U23.5 (!RESET_A)
unnamed: RA9.B2 (2), U23.14 (!RESET_B)
unnamed: RA9.C2 (2), U23.15 (!RESET_C)
VCC/1: C77.1, C78.1, C79.1, C80.P, C92.1, C93.1, C94.1, C95.P, U14.21 (PVDD_C), U14.29 (PVDD_B), U14.34 (PVDD_A), U17.21 (PVDD_C), U17.29 (PVDD_B), U17.34 (PVDD_A); also elsewhere on the board
VCC/2: C107.1, C108.1, C109.1, C110.P, C122.1, C123.1, C124.1, C125.P, U20.21 (PVDD_C), U20.29 (PVDD_B), U20.34 (PVDD_A), U23.21 (PVDD_C), U23.29 (PVDD_B), U23.34 (PVDD_A); also elsewhere on the board

Parts:
C132, C133, C136, C138, C139, C140, C141, C144, C146, C147, C148, C153, C162, C163, C164, C165: 100n; 1005
C134, C142: 1u; 1005
C135, C137, C143, C145: 22u; 2012
C149: 100u; E2.5-6.3
C150, C151, C152, C154: 1u; 1608
C155, C156, C157, C158, C159, C160: 100n; 1608
C161: 220u; E3.5-8
CN17: Dribble; PIN1X8
R98, R105: 33k; 1005
R99, R104: 100k; 1005
R100, R106: 3.9k; 1608
R101, R102, R107, R108: 51; 1005
R103, R109, R110, R111, R112, R113, R115, R116, R119, R120, R121: 10k; 1005
R114: 5m; 3216
R117: 33k; 1608
R118: 1; 1005
RA10, RA11: 51; 1005-A4
RF3, RF4: 200m; 2012
U26, U27, U30, U31: TC74VHC165FT; TSSOP16
U28, U32: ADR5041; SC70-3
U29, U33: ADS7950RGE; QFN24-0.5
U34, U35: FDG6323L; SC70-6
U36: INA219DCN; SOT23-8
U37: DRV8332; HSSOP36
U38, U40, U41: TMP05; SC70-5
U39: MCP9701/LT; SC70-6

Connections:
!ADC1_CS: R103.1, U29.16 (!CS); also elsewhere on the board
!ADC2_CS: R109.1, U33.16 (!CS); also elsewhere on the board
!MOT1_2_DO: U27.7 (!QH); also elsewhere on the board
!MOT1_2_LATCH: U26.1 (S/!L), U27.1 (S/!L); also elsewhere on the board
!MOT1_HU_5: U26.5 (G); also elsewhere on the board
!MOT1_HV_5: U26.6 (H); also elsewhere on the board
!MOT1_HW_5: U26.4 (F); also elsewhere on the board
!MOT2_HU_5: U27.13 (C); also elsewhere on the board
!MOT2_HV_5: U27.12 (B); also elsewhere on the board
!MOT2_HW_5: U27.14 (D); also elsewhere on the board
!MOT3_4_5_DO: U31.7 (!QH); also elsewhere on the board
!MOT3_4_5_LATCH: U30.1 (S/!L), U31.1 (S/!L); also elsewhere on the board
!MOT3_HU_5: U30.5 (G); also elsewhere on the board
!MOT3_HV_5: U30.6 (H); also elsewhere on the board
!MOT3_HW_5: U30.4 (F); also elsewhere on the board
!MOT4_HU_5: U31.12 (B); also elsewhere on the board
!MOT4_HV_5: U31.11 (A); also elsewhere on the board
!MOT4_HW_5: U31.13 (C); also elsewhere on the board
!MOT5_FAULT: RA10.B1 (1); also elsewhere on the board
!MOT5_HU_5: CN17.6, R119.1, U31.5 (G)
!MOT5_HV_5: CN17.7, R120.1, U31.6 (H)
!MOT5_HW_5: CN17.8, R121.1, U31.14 (D)
!MOT5_OTW: RA10.A1 (1); also elsewhere on the board
!MOT5_RESET_A: RA10.D1 (1); also elsewhere on the board
!MOT5_RESET_B: RA11.B1 (1); also elsewhere on the board
!MOT5_RESET_C: RA11.C1 (1); also elsewhere on the board
+3V3: C132.1, C133.1, C139.1, C140.1, C141.1, C147.1, C148.1, C162.1, C163.1, C164.1, C165.1, R103.2, R109.2, R115.2, R116.2, U26.16 (VCC), U27.16 (VCC), U29.21 (+VBD), U30.16 (VCC), U31.16 (VCC), U33.21 (+VBD), U36.4 (VS), U38.5 (VDD), U39.4 (VDD), U40.5 (VDD), U41.5 (VDD); also elsewhere on the board
+5V: R100.2, R101.1, R106.2, R107.1, R111.2, R113.2, U34.4 (IN), U35.4 (IN); also elsewhere on the board
+5V/2: RF3.1; also elsewhere on the board
+5V/3: CN17.4, R119.2, R120.2, R121.2, RF4.1; also elsewhere on the board
+12V: C149.P, C150.1, C151.1, C152.1, C154.1, U37.1 (GVDD_B), U37.17 (VDD), U37.18 (GVDD_C), U37.19 (GVDD_C), U37.36 (GVDD_A); also elsewhere on the board
ADC1_MISO: R102.2; also elsewhere on the board
ADC1_MOSI: U29.18 (SDI); also elsewhere on the board
ADC1_SCLK: U29.17 (SCLK); also elsewhere on the board
ADC2_MISO: R108.2; also elsewhere on the board
ADC2_MOSI: U33.18 (SDI); also elsewhere on the board
ADC2_SCLK: U33.17 (SCLK); also elsewhere on the board
GND: C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.N, C150.2, C151.2, C152.2, C154.2, C158.2, C159.2, C160.2, C161.N, C162.2, C163.2, C164.2, C165.2, CN17.5, R98.1, R105.1, R110.1, R112.1, R118.1, U26.3 (E), U26.8 (GND), U26.10 (SI), U26.13 (C), U26.14 (D), U26.15 (CKINH), U27.5 (G), U27.6 (H), U27.8 (GND), U27.15 (CKINH), U28.2 (A), U29.2 (AGND), U29.5 (AINM), U29.6 (NC), U29.7 (NC), U29.12 (NC), U29.13 (NC), U29.15 (AGND), U29.20 (BDGND), U29.23 (REFM), U29.P (AGND), U30.8 (GND), U30.10 (SI), U30.13 (C), U30.14 (D), U30.15 (CKINH), U31.8 (GND), U31.15 (CKINH), U32.2 (A), U33.2 (AGND), U33.5 (AINM), U33.6 (NC), U33.7 (NC), U33.12 (NC), U33.13 (NC), U33.15 (AGND), U33.20 (BDGND), U33.23 (REFM), U33.P (AGND), U34.1 (R2), U35.1 (R2), U36.3 (GND), U36.7 (A0), U36.8 (A1), U37.8 (GND), U37.23 (GND_C), U37.24 (GND), U37.25 (GND), U37.31 (GND_B), U37.32 (GND_A), U38.4 (GND), U39.2 (GND), U40.4 (GND), U41.4 (GND); also elsewhere on the board
MOT1_2_5V: C135.1, C136.1, C138.1, R101.2, U29.1 (+VA), U29.14 (+VA); also elsewhere on the board
MOT1_2_CLK: U26.2 (CK), U27.2 (CK); also elsewhere on the board
MOT1_2_CUR_REF: C134.1, C137.1, R100.1, U28.1 (K), U29.24 (REFP); also elsewhere on the board
MOT1_2_EN_SENSOR: R110.2, U34.5 (EN); also elsewhere on the board
MOT1_A_5: U26.12 (B); also elsewhere on the board
MOT1_B_5: U26.11 (A); also elsewhere on the board
MOT1_CUR_V: U29.10 (CH1); also elsewhere on the board
MOT1_CUR_W: U29.11 (CH0); also elsewhere on the board
MOT1_TEMP: U38.1 (OUT); also elsewhere on the board
MOT2_A_5: U27.4 (F); also elsewhere on the board
MOT2_B_5: U27.3 (E); also elsewhere on the board
MOT2_CUR_U: U29.9 (CH2); also elsewhere on the board
MOT2_CUR_V: U29.8 (CH3); also elsewhere on the board
MOT2_TEMP: U39.3 (VOUT); also elsewhere on the board
MOT3_4_5V: C143.1, C144.1, C146.1, R107.2, U33.1 (+VA), U33.14 (+VA); also elsewhere on the board
MOT3_4_5_CLK: U30.2 (CK), U31.2 (CK); also elsewhere on the board
MOT3_4_5_EN_SENSOR: R112.2, U35.5 (EN); also elsewhere on the board
MOT3_4_CUR_REF: C142.1, C145.1, R106.1, U32.1 (K), U33.24 (REFP); also elsewhere on the board
MOT3_A_5: U30.12 (B); also elsewhere on the board
MOT3_B_5: U30.11 (A); also elsewhere on the board
MOT3_CUR_V: U33.10 (CH1); also elsewhere on the board
MOT3_CUR_W: U33.11 (CH0); also elsewhere on the board
MOT3_TEMP: U40.1 (OUT); also elsewhere on the board
MOT4_A_5: U31.4 (F); also elsewhere on the board
MOT4_B_5: U31.3 (E); also elsewhere on the board
MOT4_CUR_U: U33.9 (CH2); also elsewhere on the board
MOT4_CUR_V: U33.8 (CH3); also elsewhere on the board
MOT4_TEMP: U41.1 (OUT); also elsewhere on the board
MOT5_CUR_SCL: R115.1, U36.5 (SCL); also elsewhere on the board
MOT5_CUR_SDA: R116.1, U36.6 (SDA); also elsewhere on the board
MOT5_GND: C153.2, R117.1, R118.2, U37.9 (AGND), U37.12 (M2)
MOT5_OUT_U: C155.2, CN17.1, U37.33 (OUT_A)
MOT5_OUT_V: C156.2, CN17.2, U37.30 (OUT_B)
MOT5_OUT_W: C157.2, CN17.3, U37.22 (OUT_C)
MOT5_PWM_A: RA10.C1 (1); also elsewhere on the board
MOT5_PWM_B: RA11.A1 (1); also elsewhere on the board
MOT5_PWM_C: RA11.D1 (1); also elsewhere on the board
unnamed: R98.2, R99.1, U27.11 (A)
unnamed: R104.2, R105.2, U30.3 (E)
unnamed: U33.3 (MXO), U33.4 (AINP)
unnamed: U29.3 (MXO), U29.4 (AINP)
unnamed: R117.2, U37.7 (OC_ADJ)
unnamed: C155.1, U37.35 (BST_A)
unnamed: C156.1, U37.28 (BST_B)
unnamed: R102.1, U29.19 (SDO)
unnamed: C157.1, U37.20 (BST_C)
unnamed: C153.1, U37.10 (VREG), U37.11 (M3), U37.13 (M1)
unnamed: RA11.C2 (2), U37.15 (!RESET_C)
unnamed: RA11.B2 (2), U37.14 (!RESET_B)
unnamed: RA10.D2 (2), U37.5 (!RESET_A)
unnamed: RA11.D2 (2), U37.16 (PWM_C)
unnamed: RA11.A2 (2), U37.6 (PWM_B)
unnamed: RA10.C2 (2), U37.4 (PWM_A)
unnamed: RA10.B2 (2), U37.3 (!FAULT)
unnamed: RA10.A2 (2), U37.2 (!OTW)
unnamed: R108.1, U33.19 (SDO)
unnamed: C158.1, C159.1, C160.1, C161.P, R114.2, U36.2 (VIN-), U37.21 (PVDD_C), U37.29 (PVDD_B), U37.34 (PVDD_A)
unnamed: U26.9 (QH), U27.10 (SI)
unnamed: U30.9 (QH), U31.10 (SI)
unnamed: RF3.2, U34.2 (OUT), U34.3 (OUT)
unnamed: RF4.2, U35.2 (OUT), U35.3 (OUT)
unnamed: R111.1, U34.6 (R1)
unnamed: R113.1, U35.6 (R1)
VCC/1: R99.2; also elsewhere on the board
VCC/2: R104.1, R114.1, U36.1 (VIN+); also elsewhere on the board

Notes on the sheet:
温度センサーはU39のみ実装

Board: 2 copper layers, 150.0 x 100.0 mm, 405 parts (190 on the bottom side), 364 nets.
